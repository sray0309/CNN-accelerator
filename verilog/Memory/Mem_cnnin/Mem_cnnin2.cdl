*
* Copyright 2020 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3e
* Version: 2009Q1V1
* Name: High Speed/Density Dual Port SRAM Generator|IBM CMRF8SF-LPVT Process
* Comment:
* Configuration:  -instname "Mem_cnnin2" -words 256 -bits 64 -frequ\
* Configuration: ency 1 -ring_width 4.0 -mux 4 -write_mask off -wp_\
* Configuration: size 8 -top_layer "met5-8" -power_type rings -hori\
* Configuration: z met3 -vert met4 -cust_comment "" -bus_notation o\
* Configuration: n -left_bus_delim "[" -right_bus_delim "]" -pwr_gn\
* Configuration: d_rename "VDD:VDD,GND:VSS" -prefix "" -pin_space 0\
* Configuration: .0 -name_case upper -check_instname on -diodes on \
* Configuration: -inside_ring_type GND -drive 6 -dpccm on -asvm on \
* Configuration: -corners ff_1p32v_m40c,ff_1p65v_125c,tt_1p2v_25c,s\
* Configuration: s_1p08v_125c
* Codefile:
*
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT Mem_cnnin2FCBWM4 BWEN BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWM4: 2 flat devices **
d1 VSS Q tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS D tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCBWM4
****
.SUBCKT Mem_cnnin2FCBWM4A BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWM4A: 2 flat devices **
XI0_0 BWENA BWENA BWENB D Q VDD VSS Mem_cnnin2FCBWM4
.ENDS Mem_cnnin2FCBWM4A
****
.SUBCKT Mem_cnnin2FCBWM4B BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWM4B: 2 flat devices **
XI0_0 BWENB BWENA BWENB D Q VDD VSS Mem_cnnin2FCBWM4
.ENDS Mem_cnnin2FCBWM4B
****
.SUBCKT Mem_cnnin2IO4 BWE BWEN D DPN DPU DW DW_ GTP2 GTPA GTPB OEA_ OEB_ OE_ Q
+  SP STUBWEA STUBWEB STUBWEIA STUBWEIB WE WEA WEB VDD VSS
** Mem_cnnin2IO4: 58 flat devices **
m1 QI DPU VSS VSS NFET L=0.12U W=1.25U
m10 QPD OEI_ VSS VSS lpnfet L=0.12U W=0.28U
m11 QIL QI VDD VDD lppfet L=0.12U W=0.33U
m12 QIL QI VSS VSS lpnfet L=0.12U W=0.26U
m13 SPN SP VDD VDD lppfet L=0.12U W=0.17U
m14 SPN SP VSS VSS lpnfet L=0.12U W=0.16U
m15 DWPD GTPND DWI VSS lpnfet L=0.12U W=0.75U
m16 DWPD DW VDD VDD lppfet L=0.22U W=0.16U
m17 DWPD DW VSS VSS lpnfet L=0.42U W=0.16U
m18 DWPD GTP2 DWI VDD lppfet L=0.12U W=0.88U
m19 DW_PU GTPND DNWI VSS lpnfet L=0.12U W=0.75U
m2 QI DPN VDD VDD PFET L=0.12U W=2.4U
m20 DW_PU GTP2 DNWI VDD lppfet L=0.12U W=0.88U
m21 GTPND GTP2 VDD VDD lppfet L=0.12U W=0.2U
m22 GTPND GTP2 VSS VSS lpnfet L=0.12U W=0.19U
m23 DI N56 VDD VDD lppfet L=0.12U W=0.72U
m24 DI N56 VSS VSS lpnfet L=0.12U W=0.43U
m25 DNN DI VDD VDD lppfet L=0.12U W=0.55U
m26 DNN DI VSS VSS lpnfet L=0.12U W=0.31U
m27 WEI N61 VDD VDD lppfet L=0.12U W=0.63U
m28 WEI N61 VSS VSS lpnfet L=0.12U W=0.44U
m29 OEI OEI_ VDD VDD lppfet L=0.12U W=0.3U
m3 Q QPU VDD VDD lppfet L=0.12U W=3.96U
m30 OEI OEI_ VSS VSS lpnfet L=0.12U W=0.21U
m31 QI SP N87 VDD lppfet L=0.12U W=0.72U
m32 N87 QIL VDD VDD lppfet L=0.12U W=0.72U
m33 QI SPN N86 VSS lpnfet L=0.12U W=0.72U
m34 N86 QIL VSS VSS lpnfet L=0.12U W=0.72U
m35 N43 OE_ VDD VDD lppfet L=0.12U W=0.22U
m36 N43 OE_ VSS VSS lpnfet L=0.12U W=0.16U
m37 N61 WE VDD VDD lppfet L=0.12U W=0.22U
m38 N61 WE VSS VSS lpnfet L=0.12U W=0.18U
m39 DWI WEI VDD VDD lppfet L=0.12U W=1.24U
m4 Q QPD VSS VSS lpnfet L=0.12U W=2.6U
m40 N88 WEI VSS VSS lpnfet L=0.12U W=0.93U
m41 DWI DI VDD VDD lppfet L=0.12U W=1.24U
m42 DWI DI N88 VSS lpnfet L=0.12U W=0.93U
m43 DNWI WEI VDD VDD lppfet L=0.12U W=1.24U
m44 N89 WEI VSS VSS lpnfet L=0.12U W=0.93U
m45 DNWI DNN VDD VDD lppfet L=0.12U W=1.24U
m46 DNWI DNN N89 VSS lpnfet L=0.12U W=0.93U
m47 N56 D VDD VDD lppfet L=0.12U W=0.23U
m48 N56 D VSS VSS lpnfet L=0.12U W=0.16U
m49 QPU OEI_ QI VDD PFET L=0.12U W=0.16U
m5 OEI_ N43 VDD VDD lppfet L=0.12U W=0.7U
m50 QPD OEI QI VSS NFET L=0.12U W=0.17U
m51 DW DWPD VDD VDD PFET L=0.12U W=3.14U
m52 DW DWPD VSS VSS NFET L=0.12U W=2.12U
m53 DW_PU DW_ VDD VDD lppfet L=0.22U W=0.16U
m54 DW_PU DW_ VSS VSS lpnfet L=0.46U W=0.16U
m55 DW_ DW_PU VDD VDD PFET L=0.12U W=3.14U
m56 DW_ DW_PU VSS VSS NFET L=0.12U W=2.12U
m57 BWE BWEN VDD VDD lppfet L=0.12U W=0.7U
m58 BWE BWEN VSS VSS lpnfet L=0.12U W=0.48U
m6 OEI_ N43 VSS VSS lpnfet L=0.12U W=0.48U
m7 QPD OEI_ QI VDD PFET L=0.12U W=1.78U
m8 QPU OEI QI VSS NFET L=0.12U W=1.18U
m9 QPU OEI VDD VDD lppfet L=0.12U W=0.47U
.ENDS Mem_cnnin2IO4
****
.SUBCKT Mem_cnnin2IOXX_A D DPN DPU DW DW_ GTPA GTPB OEA_ OEB_ Q SP STUBWEIA
+  STUBWEIB VDD VSS
** Mem_cnnin2IOXX_A: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTPA GTPA GTPB OEA_ OEB_ OEA_ Q SP STUBWEIA
+  STUBWEIB STUBWEIA STUBWEIB STUBWEIA STUBWEIA STUBWEIB VDD VSS Mem_cnnin2IO4
.ENDS Mem_cnnin2IOXX_A
****
.SUBCKT Mem_cnnin2IOXX_B D DPN DPU DW DW_ GTPA GTPB OEA_ OEB_ Q SP STUBWEIA
+  STUBWEIB VDD VSS
** Mem_cnnin2IOXX_B: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTPB GTPA GTPB OEA_ OEB_ OEB_ Q SP STUBWEIA
+  STUBWEIB STUBWEIA STUBWEIB STUBWEIB STUBWEIA STUBWEIB VDD VSS Mem_cnnin2IO4
.ENDS Mem_cnnin2IOXX_B
****
.SUBCKT Mem_cnnin2SA4 DPN DPU DR DR_ DW DW_ GTP GTPA GTPB SP VDD VSS
** Mem_cnnin2SA4: 41 flat devices **
m1 N23 SRCD VSS VSS lpnfet L=0.12U W=1.07U
m10 DPN SDN VDD VDD lppfet L=0.12U W=0.81U
m11 DPN SDN VSS VSS lpnfet L=0.12U W=2.06U
m12 SP SPN VDD VDD lppfet L=0.12U W=0.95U
m13 SP SPN VSS VSS lpnfet L=0.12U W=0.78U
m14 GTPN GTP VDD VDD lppfet L=0.12U W=0.3U
m15 GTPN GTP VSS VSS lpnfet L=0.12U W=0.17U
m16 ND1 GTPN VDD VDD lppfet L=0.12U W=0.2U
m17 ND1 GTPN VSS VSS lpnfet L=0.12U W=0.16U
m18 ND2 ND1 VDD VDD lppfet L=0.12U W=0.68U
m19 ND2 ND1 VSS VSS lpnfet L=0.12U W=0.4U
m2 SD SP DR VDD lppfet L=0.12U W=1.65U
m20 N41 DRP VSS VSS lpnfet L=0.12U W=0.6U
m21 SPN GTPN N41 VSS lpnfet L=0.12U W=0.41U
m22 SPN DRP VDD VDD lppfet L=0.12U W=0.4U
m23 SPN GTPN VDD VDD lppfet L=0.12U W=0.24U
m24 DRP ND2 VDD VDD lppfet L=0.12U W=1.47U
m25 DRP ND2 VSS VSS lpnfet L=0.12U W=1.35U
m26 DR_ DRP VDD VDD lppfet L=0.12U W=1.74U
m27 DR DRP VDD VDD lppfet L=0.12U W=1.74U
m28 DR DRP DR_ VDD lppfet L=0.12U W=2.04U
m29 SD_ SD SRC VSS lpnfet L=0.19U W=3.6U
m3 SD_ SP DR_ VDD lppfet L=0.12U W=1.65U
m30 SD SD_ SRC VSS lpnfet L=0.19U W=3.6U
m33 SRC GTPN N23 VSS lpnfet L=0.12U W=1.17U
m34 SRCD SRCPU VDD VDD lppfet L=0.12U W=0.46U
m35 SRCD SRCPU VSS VSS lpnfet L=0.12U W=0.24U
m36 SRCPU DRP VDD VDD lppfet L=0.12U W=0.43U
m37 SRCPU DRP VSS VSS lpnfet L=0.12U W=0.24U
m38 VDD SRCPU SRC VSS lpnfet L=0.12U W=1.18U
m39 SD SRCD SD_ VDD lppfet L=0.12U W=0.5U
m4 SD_ SD VDD VDD lppfet L=0.12U W=0.5U
m40 SRC GTPN N53 VSS lpnfet L=0.12U W=1.17U
m41 N53 SRCD VSS VSS lpnfet L=0.12U W=1.07U
m5 SD SD_ VDD VDD lppfet L=0.12U W=0.5U
m6 SDN SD VDD VDD lppfet L=0.12U W=0.86U
m7 SDN SD VSS VSS lpnfet L=0.12U W=0.42U
m8 DPU SD_ VDD VDD lppfet L=0.12U W=0.86U
m9 DPU SD_ VSS VSS lpnfet L=0.12U W=0.42U
m9998 SD_ SPN DR_ VSS lpnfet W=0.28U L=0.12U
m9999 SD SPN DR VSS lpnfet W=0.28U L=0.12U
.ENDS Mem_cnnin2SA4
****
.SUBCKT Mem_cnnin2SAX_A DPN DPU DR DR_ DW DW_ GTPA GTPB SP VDD VSS
** Mem_cnnin2SAX_A: 41 flat devices **
XI0_0 DPN DPU DR DR_ DW DW_ GTPA GTPA GTPB SP VDD VSS Mem_cnnin2SA4
.ENDS Mem_cnnin2SAX_A
****
.SUBCKT Mem_cnnin2SAX_B DPN DPU DR DR_ DW DW_ GTPA GTPB SP VDD VSS
** Mem_cnnin2SAX_B: 41 flat devices **
XI0_0 DPN DPU DR DR_ DW DW_ GTPB GTPA GTPB SP VDD VSS Mem_cnnin2SA4
.ENDS Mem_cnnin2SAX_B
****
.SUBCKT Mem_cnnin2CD A0 A0A A0A_ A0B A0B_ A0_ BL0 BL0_ BL1 BL1_ DR DRA DRA_
+  DRB DRB_ DRSA DR_ DW DWA DWA_ DWB DWB_ DWSA DW_ G0 G1 GTP GTPA GTPB STUBDRA
+  STUBDRA_ STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2CD: 47 flat devices **
m1 BL0_ CS0 DR_ VDD PFET L=0.12U W=2.28U
m10 BL1_ BL1PD VSS VSS NFET L=0.12U W=4.8U
m11 BL1_PD CS1 DW_ VDD PFET L=0.12U W=1.84U
m12 BL1_PD CS1 VSS VSS lpnfet L=0.12U W=0.64U
m13 BL1_ CS1 DR_ VDD PFET L=0.12U W=2.28U
m14 BL1PD CS1 DW VDD PFET L=0.12U W=1.84U
m15 BL1PD CS1 VSS VSS lpnfet L=0.12U W=0.64U
m16 BL1 BL1_PD VSS VSS NFET L=0.12U W=4.8U
m17 BL0_ YI VDD VDD lppfet L=0.12U W=4.14U
m18 BL0 YI VDD VDD lppfet L=0.12U W=4.14U
m19 BL0 YI BL0_ VDD lppfet L=0.12U W=4.14U
m2 BL0 BL0PD VSS VSS NFET L=0.12U W=4.8U
m20 BL1 YI VDD VDD lppfet L=0.12U W=4.14U
m21 BL1_ YI VDD VDD lppfet L=0.12U W=4.14U
m22 BL1_ YI BL1 VDD lppfet L=0.12U W=4.14U
m23 CS0 A0_ VDD VDD lppfet L=0.12U W=1.04U
m24 N91 A0_ VSS VSS lpnfet L=0.12U W=1.45U
m25 CS0 YI VDD VDD lppfet L=0.12U W=1.04U
m26 CS0 YI N91 VSS lpnfet L=0.12U W=1.45U
m27 CS1 A0 VDD VDD lppfet L=0.12U W=1.04U
m28 N92 A0 VSS VSS lpnfet L=0.12U W=1.45U
m29 CS1 YI VDD VDD lppfet L=0.12U W=1.04U
m3 BL0_PD CS0 DW VDD PFET L=0.12U W=1.84U
m30 CS1 YI N92 VSS lpnfet L=0.12U W=1.45U
m31 YCDSEL_ G0 VDD VDD lppfet L=0.12U W=0.3U
m32 N93 G0 VSS VSS lpnfet L=0.12U W=0.38U
m33 YCDSEL_ G1 VDD VDD lppfet L=0.12U W=0.3U
m34 YCDSEL_ G1 N93 VSS lpnfet L=0.12U W=0.38U
m35 YCDSEL YCDSEL_ VDD VDD lppfet L=0.12U W=0.24U
m36 YCDSEL YCDSEL_ VSS VSS lpnfet L=0.12U W=0.16U
m37 N63 YCDSEL_ GTP VDD lppfet L=0.12U W=0.3U
m38 N63 YCDSEL_ VSS VSS lpnfet L=0.12U W=0.3U
m39 YI WL1_EN_ VDD VDD lppfet L=0.12U W=3.62U
m4 BL0_PD CS0 VSS VSS lpnfet L=0.12U W=0.64U
m40 YI WL1_EN_ VSS VSS lpnfet L=0.12U W=2.9U
m41 WL1_EN_ N63 VDD VDD lppfet L=0.12U W=1.48U
m42 WL1_EN_ N63 VSS VSS lpnfet L=0.12U W=0.94U
m43 N63 YCDSEL GTP VSS lpnfet L=0.12U W=0.3U
m5 BL0 CS0 DR VDD PFET L=0.12U W=2.28U
m6 BL0PD CS0 DW_ VDD PFET L=0.12U W=1.84U
m7 BL0PD CS0 VSS VSS lpnfet L=0.12U W=0.64U
m8 BL0_ BL0_PD VSS VSS NFET L=0.12U W=4.8U
m9 BL1 CS1 DR VDD PFET L=0.12U W=2.28U
m9996 BL1_ BL1PD DR_ VSS lpnfet W=0.28U L=0.12U
m9997 BL1 BL1_PD DR VSS lpnfet W=0.28U L=0.12U
m9998 BL0_ BL0_PD DR_ VSS lpnfet W=0.28U L=0.12U
m9999 BL0 BL0PD DR VSS lpnfet W=0.28U L=0.12U
.ENDS Mem_cnnin2CD
****
.SUBCKT Mem_cnnin2MXCD_EVEN_RIGHT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ DRSA_0 DRSA_1
+  DRSA_2 DRSA_3 DWSA_0 DWSA_1 DWSA_2 DWSA_3 GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MXCD_EVEN_RIGHT: 188 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA0 BLA0_ BLA1 BLA1_ DRSA_0 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_0 DRSA_1 DWSA_0 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_0
+  DWSA_1 YPA0_0 VDD GTPA GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI1_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB0 BLB0_ BLB1 BLB1_ DRSA_3 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_1 DRSA_2 DWSA_3 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_1
+  DWSA_2 YPB0_0 VDD GTPB GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI2_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB2 BLB2_ BLB3 BLB3_ DRSA_3 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_2 DRSA_2 DWSA_3 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_2
+  DWSA_2 YPB0_1 VDD GTPB GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI3_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA2 BLA2_ BLA3 BLA3_ DRSA_0 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_3 DRSA_1 DWSA_0 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_3
+  DWSA_1 YPA0_1 VDD GTPA GTPA GTPB STUBDRA STUBDRA_ STUBDRB STUBDRB_ STUBDWA
+  STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
.ENDS Mem_cnnin2MXCD_EVEN_RIGHT
****
.SUBCKT Mem_cnnin2CCG BLA BLA_ BLB BLB_ WLA WLB VDD VSS
** Mem_cnnin2CCG: 8 flat devices **
m1 BLB WLB CORED VSS lpnfet L=0.13U W=0.16U
m2 BLB_ WLB CORED_ VSS lpnfet L=0.13U W=0.16U
m3 BLA WLA CORED VSS lpnfet L=0.13U W=0.16U
m4 BLA_ WLA CORED_ VSS lpnfet L=0.13U W=0.16U
m5 CORED_ CORED VDD VDD lppfet L=0.12U W=0.16U
m6 CORED_ CORED VSS VSS lpnfet L=0.12U W=0.8U
m7 CORED CORED_ VDD VDD lppfet L=0.12U W=0.16U
m8 CORED CORED_ VSS VSS lpnfet L=0.12U W=0.8U
.ENDS Mem_cnnin2CCG
****
.SUBCKT Mem_cnnin2CCP BLA BLA_ BLB BLB_ WLA WLB VDD VSS
** Mem_cnnin2CCP: 8 flat devices **
m1 BLB WLB CORED VSS lpnfet L=0.13U W=0.16U
m2 BLB_ WLB CORED_ VSS lpnfet L=0.13U W=0.16U
m3 BLA WLA CORED VSS lpnfet L=0.13U W=0.16U
m4 BLA_ WLA CORED_ VSS lpnfet L=0.13U W=0.16U
m5 CORED_ CORED VDD VDD lppfet L=0.12U W=0.16U
m6 CORED_ CORED VSS VSS lpnfet L=0.12U W=0.8U
m7 CORED CORED_ VDD VDD lppfet L=0.12U W=0.16U
m8 CORED CORED_ VSS VSS lpnfet L=0.12U W=0.8U
.ENDS Mem_cnnin2CCP
****
.SUBCKT Mem_cnnin2BIT_MUX_1 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2
+  BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA WLB VDD VSS
** Mem_cnnin2BIT_MUX_1: 32 flat devices **
XI0_0 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VDD VSS Mem_cnnin2CCG
XI1_0 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VDD VSS Mem_cnnin2CCP
XI2_0 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VDD VSS Mem_cnnin2CCP
XI3_0 BLA_3 BLA__3 BLB_3 BLB__3 WLA WLB VDD VSS Mem_cnnin2CCG
.ENDS Mem_cnnin2BIT_MUX_1
****
.SUBCKT Mem_cnnin2BIT_MUX_0 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2
+  BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA WLB VDD VSS
** Mem_cnnin2BIT_MUX_0: 32 flat devices **
XI0_0 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VDD VSS Mem_cnnin2CCG
XI1_0 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VDD VSS Mem_cnnin2CCP
XI2_0 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VDD VSS Mem_cnnin2CCP
XI3_0 BLA_3 BLA__3 BLB_3 BLB__3 WLA WLB VDD VSS Mem_cnnin2CCG
.ENDS Mem_cnnin2BIT_MUX_0
****
.SUBCKT Mem_cnnin2BIT_COL BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1
+  WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD
+  VSS
** Mem_cnnin2BIT_COL: 2048 flat devices **
XI0_0 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_0 WLB_0 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_1 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_1 WLB_1 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_10 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_10 WLB_10 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_11 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_11 WLB_11 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_12 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_12 WLB_12 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_13 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_13 WLB_13 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_14 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_14 WLB_14 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_15 WLB_15 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_16 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_16 WLB_16 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_17 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_17 WLB_17 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_18 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_18 WLB_18 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_19 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_19 WLB_19 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_2 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_2 WLB_2 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_20 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_20 WLB_20 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_21 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_21 WLB_21 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_22 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_22 WLB_22 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_23 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_23 WLB_23 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_24 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_24 WLB_24 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_25 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_25 WLB_25 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_26 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_26 WLB_26 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_27 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_27 WLB_27 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_28 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_28 WLB_28 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_29 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_29 WLB_29 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_3 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_3 WLB_3 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_30 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_30 WLB_30 VDD VSS
+  Mem_cnnin2BIT_MUX_0
XI0_31 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_31 WLB_31 VDD VSS
+  Mem_cnnin2BIT_MUX_1
XI0_33 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_32 WLB_32 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_34 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_33 WLB_33 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_35 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_34 WLB_34 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_36 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_35 WLB_35 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_37 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_36 WLB_36 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_38 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_37 WLB_37 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_39 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_38 WLB_38 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_4 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_4 WLB_4 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_40 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_39 WLB_39 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_41 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_40 WLB_40 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_42 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_41 WLB_41 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_43 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_42 WLB_42 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_44 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_43 WLB_43 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_45 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_44 WLB_44 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_46 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_45 WLB_45 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_47 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_46 WLB_46 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_48 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_47 WLB_47 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_49 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_48 WLB_48 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_5 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_5 WLB_5 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_50 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_49 WLB_49 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_51 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_50 WLB_50 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_52 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_51 WLB_51 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_53 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_52 WLB_52 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_54 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_53 WLB_53 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_55 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_54 WLB_54 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_56 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_55 WLB_55 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_57 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_56 WLB_56 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_58 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_57 WLB_57 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_59 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_58 WLB_58 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_6 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_6 WLB_6 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_60 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_59 WLB_59 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_61 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_60 WLB_60 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_62 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_61 WLB_61 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_63 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_62 WLB_62 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_64 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_63 WLB_63 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_7 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_7 WLB_7 VDD VSS Mem_cnnin2BIT_MUX_1
XI0_8 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_8 WLB_8 VDD VSS Mem_cnnin2BIT_MUX_0
XI0_9 BLA__0 BLA__1 BLA__2 BLA__3 BLA_0 BLA_1 BLA_2 BLA_3 BLB__0 BLB__1 BLB__2
+  BLB__3 BLB_0 BLB_1 BLB_2 BLB_3 WLA_9 WLB_9 VDD VSS Mem_cnnin2BIT_MUX_1
.ENDS Mem_cnnin2BIT_COL
****
.SUBCKT Mem_cnnin2MCOL_MER4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_MER4: 2438 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWM4A
XI0_1 D_0 DPN DPU STUBDWA_1 STUBDWA__1 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_1 STUBDRA__1 STUBDWA_1 STUBDWA__1 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLA__3 BLA_3
+  BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 BLB__3 BLB_3 STUBDRA_1 STUBDRA__1
+  STUBDRB__1 STUBDRB_1 STUBDWA_1 STUBDWA__1 STUBDWB__1 STUBDWB_1 GTPA_2
+  GTPB_2 STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_EVEN_RIGHT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_1 STUBDWB__1 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_1 STUBDRB__1 STUBDWB_1 STUBDWB__1 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_MER4
****
.SUBCKT Mem_cnnin2MXCD_ODD_RIGHT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ GTPA GTPB
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MXCD_ODD_RIGHT: 188 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA2 BLA2_ BLA3 BLA3_ STUBDRA_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWA_0 STUBDWA__0 YPA0_1 VDD GTPA GTPA
+  GTPB STUBDRA_1 STUBDRA__1 STUBDRB_1 STUBDRB__1 STUBDWA_1 STUBDWA__1
+  STUBDWB_1 STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI1_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB2 BLB2_ BLB3 BLB3_ STUBDRB_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRA__0 STUBDRB__0 STUBDWB_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWA__0 STUBDWB__0 YPB0_1 VDD GTPB GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI2_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB0 BLB0_ BLB1 BLB1_ STUBDRB_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRB__0 STUBDRB__0 STUBDWB_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWB__0 STUBDWB__0 YPB0_0 VDD GTPB GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI3_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA0 BLA0_ BLA1 BLA1_ STUBDRA_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRB_0 STUBDRA__0 STUBDWA_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWB_0 STUBDWA__0 YPA0_0 VDD GTPA GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
.ENDS Mem_cnnin2MXCD_ODD_RIGHT
****
.SUBCKT Mem_cnnin2MCOL_MOR4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_MOR4: 2438 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWM4A
XI0_1 D_0 DPN DPU STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__3 BLA_3 BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0
+  BLB__3 BLB_3 BLB__2 BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 GTPA_2 GTPB_2 STUBDRA_0
+  STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0 STUBDRB__1
+  STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1 STUBDWB__0
+  STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_ODD_RIGHT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_MOR4
****
.SUBCKT Mem_cnnin2FCBWRO4 BWEN BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWRO4: 3 flat devices **
d1 VSS Q tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS D tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCBWRO4
****
.SUBCKT Mem_cnnin2FCBWRO4A BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWRO4A: 3 flat devices **
XI0_0 BWENA BWENA BWENB D Q VDD VSS Mem_cnnin2FCBWRO4
.ENDS Mem_cnnin2FCBWRO4A
****
.SUBCKT Mem_cnnin2MCOL_ROR4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_ROR4: 2439 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWRO4A
XI0_1 D_0 DPN DPU STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__3 BLA_3 BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0
+  BLB__3 BLB_3 BLB__2 BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 GTPA_2 GTPB_2 STUBDRA_0
+  STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0 STUBDRB__1
+  STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1 STUBDWB__0
+  STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_ODD_RIGHT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_ROR4
****
.SUBCKT Mem_cnnin2WING_32_RIGHT A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3
+  BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14
+  BLA_15 BLA_16 BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24
+  BLA_25 BLA_26 BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34
+  BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44
+  BLA_45 BLA_46 BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54
+  BLA_55 BLA_56 BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64
+  BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74
+  BLA_75 BLA_76 BLA_77 BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84
+  BLA_85 BLA_86 BLA_87 BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94
+  BLA_95 BLA_96 BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104
+  BLA_105 BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113
+  BLA_114 BLA_115 BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122
+  BLA_123 BLA_124 BLA_125 BLA_126 BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23
+  BLA__24 BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32
+  BLA__33 BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41
+  BLA__42 BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50
+  BLA__51 BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59
+  BLA__60 BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68
+  BLA__69 BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77
+  BLA__78 BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86
+  BLA__87 BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95
+  BLA__96 BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103
+  BLA__104 BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111
+  BLA__112 BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119
+  BLA__120 BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11
+  BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21
+  BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31
+  BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41
+  BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51
+  BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61
+  BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71
+  BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81
+  BLB_82 BLB_83 BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91
+  BLB_92 BLB_93 BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101
+  BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110
+  BLB_111 BLB_112 BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119
+  BLB_120 BLB_121 BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0
+  BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10
+  BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19
+  BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28
+  BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37
+  BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46
+  BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55
+  BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82
+  BLB__83 BLB__84 BLB__85 BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91
+  BLB__92 BLB__93 BLB__94 BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 BLB__112 BLB__113 BLB__114 BLB__115 BLB__116
+  BLB__117 BLB__118 BLB__119 BLB__120 BLB__121 BLB__122 BLB__123 BLB__124
+  BLB__125 BLB__126 BLB__127 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23 D_24 D_25
+  D_26 D_27 D_28 D_29 D_30 D_31 D_32 D_33 D_34 D_35 D_36 D_37 D_38 D_39 D_40
+  D_41 D_42 D_43 D_44 D_45 D_46 D_47 D_48 D_49 D_50 D_51 D_52 D_53 D_54 D_55
+  D_56 D_57 D_58 D_59 D_60 D_61 D_62 D_63 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1
+  GTPB_2 OEA_ OEB_ Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12
+  Q_13 Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20 Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27
+  Q_28 Q_29 Q_30 Q_31 Q_32 Q_33 Q_34 Q_35 Q_36 Q_37 Q_38 Q_39 Q_40 Q_41 Q_42
+  Q_43 Q_44 Q_45 Q_46 Q_47 Q_48 Q_49 Q_50 Q_51 Q_52 Q_53 Q_54 Q_55 Q_56 Q_57
+  Q_58 Q_59 Q_60 Q_61 Q_62 Q_63 STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1
+  STUBDRB_0 STUBDRB_1 STUBDRB__0 STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0
+  STUBDWA__1 STUBDWB_0 STUBDWB_1 STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10
+  WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20
+  WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30
+  WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40
+  WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50
+  WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60
+  WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2WING_32_RIGHT: 78017 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 D_0 D_1 GTPA_0 GTPA_1
+  GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1 STUBDRA_0_274 STUBDRA_1
+  STUBDRA__0_272 STUBDRA__1 STUBDRB_0_278 STUBDRB_1 STUBDRB__0_276 STUBDRB__1
+  STUBDWA_0_280 STUBDWA_1 STUBDWA__0_282 STUBDWA__1 STUBDWB_0_284 STUBDWB_1
+  STUBDWB__0_286 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI10_0 A0A A0A_ A0B A0B_ BLA_40 BLA_41 BLA_42 BLA_43 BLA__40 BLA__41 BLA__42
+  BLA__43 BLB_40 BLB_41 BLB_42 BLB_43 BLB__40 BLB__41 BLB__42 BLB__43 D_20
+  D_21 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_20 Q_21
+  STUBDRA_0_82 STUBDRA_1_98 STUBDRA__0_80 STUBDRA__1_96 STUBDRB_0_86
+  STUBDRB_1_102 STUBDRB__0_84 STUBDRB__1_100 STUBDWA_0_88 STUBDWA_1_104
+  STUBDWA__0_90 STUBDWA__1_106 STUBDWB_0_92 STUBDWB_1_108 STUBDWB__0_94
+  STUBDWB__1_110 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI11_0 A0A A0A_ A0B A0B_ BLA_47 BLA_46 BLA_45 BLA_44 BLA__47 BLA__46 BLA__45
+  BLA__44 BLB_47 BLB_46 BLB_45 BLB_44 BLB__47 BLB__46 BLB__45 BLB__44 D_23
+  D_22 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_23 Q_22
+  STUBDRA_0_82 STUBDRA_1_114 STUBDRA__0_80 STUBDRA__1_112 STUBDRB_0_86
+  STUBDRB_1_118 STUBDRB__0_84 STUBDRB__1_116 STUBDWA_0_88 STUBDWA_1_120
+  STUBDWA__0_90 STUBDWA__1_122 STUBDWB_0_92 STUBDWB_1_124 STUBDWB__0_94
+  STUBDWB__1_126 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI12_0 A0A A0A_ A0B A0B_ BLA_48 BLA_49 BLA_50 BLA_51 BLA__48 BLA__49 BLA__50
+  BLA__51 BLB_48 BLB_49 BLB_50 BLB_51 BLB__48 BLB__49 BLB__50 BLB__51 D_24
+  D_25 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_24 Q_25
+  STUBDRA_0_146 STUBDRA_1_114 STUBDRA__0_144 STUBDRA__1_112 STUBDRB_0_150
+  STUBDRB_1_118 STUBDRB__0_148 STUBDRB__1_116 STUBDWA_0_152 STUBDWA_1_120
+  STUBDWA__0_154 STUBDWA__1_122 STUBDWB_0_156 STUBDWB_1_124 STUBDWB__0_158
+  STUBDWB__1_126 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI13_0 A0A A0A_ A0B A0B_ BLA_55 BLA_54 BLA_53 BLA_52 BLA__55 BLA__54 BLA__53
+  BLA__52 BLB_55 BLB_54 BLB_53 BLB_52 BLB__55 BLB__54 BLB__53 BLB__52 D_27
+  D_26 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_27 Q_26
+  STUBDRA_0_146 STUBDRA_1_162 STUBDRA__0_144 STUBDRA__1_160 STUBDRB_0_150
+  STUBDRB_1_166 STUBDRB__0_148 STUBDRB__1_164 STUBDWA_0_152 STUBDWA_1_168
+  STUBDWA__0_154 STUBDWA__1_170 STUBDWB_0_156 STUBDWB_1_172 STUBDWB__0_158
+  STUBDWB__1_174 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI14_0 A0A A0A_ A0B A0B_ BLA_56 BLA_57 BLA_58 BLA_59 BLA__56 BLA__57 BLA__58
+  BLA__59 BLB_56 BLB_57 BLB_58 BLB_59 BLB__56 BLB__57 BLB__58 BLB__59 D_28
+  D_29 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_28 Q_29
+  STUBDRA_0_178 STUBDRA_1_162 STUBDRA__0_176 STUBDRA__1_160 STUBDRB_0_182
+  STUBDRB_1_166 STUBDRB__0_180 STUBDRB__1_164 STUBDWA_0_184 STUBDWA_1_168
+  STUBDWA__0_186 STUBDWA__1_170 STUBDWB_0_188 STUBDWB_1_172 STUBDWB__0_190
+  STUBDWB__1_174 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI15_0 A0A A0A_ A0B A0B_ BLA_63 BLA_62 BLA_61 BLA_60 BLA__63 BLA__62 BLA__61
+  BLA__60 BLB_63 BLB_62 BLB_61 BLB_60 BLB__63 BLB__62 BLB__61 BLB__60 D_31
+  D_30 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_31 Q_30
+  STUBDRA_0_178 STUBDRA_1_194 STUBDRA__0_176 STUBDRA__1_192 STUBDRB_0_182
+  STUBDRB_1_198 STUBDRB__0_180 STUBDRB__1_196 STUBDWA_0_184 STUBDWA_1_200
+  STUBDWA__0_186 STUBDWA__1_202 STUBDWB_0_188 STUBDWB_1_204 STUBDWB__0_190
+  STUBDWB__1_206 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI16_0 A0A A0A_ A0B A0B_ BLA_64 BLA_65 BLA_66 BLA_67 BLA__64 BLA__65 BLA__66
+  BLA__67 BLB_64 BLB_65 BLB_66 BLB_67 BLB__64 BLB__65 BLB__66 BLB__67 D_32
+  D_33 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_32 Q_33
+  STUBDRA_0_210 STUBDRA_1_194 STUBDRA__0_208 STUBDRA__1_192 STUBDRB_0_214
+  STUBDRB_1_198 STUBDRB__0_212 STUBDRB__1_196 STUBDWA_0_216 STUBDWA_1_200
+  STUBDWA__0_218 STUBDWA__1_202 STUBDWB_0_220 STUBDWB_1_204 STUBDWB__0_222
+  STUBDWB__1_206 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI17_0 A0A A0A_ A0B A0B_ BLA_71 BLA_70 BLA_69 BLA_68 BLA__71 BLA__70 BLA__69
+  BLA__68 BLB_71 BLB_70 BLB_69 BLB_68 BLB__71 BLB__70 BLB__69 BLB__68 D_35
+  D_34 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_35 Q_34
+  STUBDRA_0_210 STUBDRA_1_226 STUBDRA__0_208 STUBDRA__1_224 STUBDRB_0_214
+  STUBDRB_1_230 STUBDRB__0_212 STUBDRB__1_228 STUBDWA_0_216 STUBDWA_1_232
+  STUBDWA__0_218 STUBDWA__1_234 STUBDWB_0_220 STUBDWB_1_236 STUBDWB__0_222
+  STUBDWB__1_238 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI18_0 A0A A0A_ A0B A0B_ BLA_72 BLA_73 BLA_74 BLA_75 BLA__72 BLA__73 BLA__74
+  BLA__75 BLB_72 BLB_73 BLB_74 BLB_75 BLB__72 BLB__73 BLB__74 BLB__75 D_36
+  D_37 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_36 Q_37
+  STUBDRA_0_242 STUBDRA_1_226 STUBDRA__0_240 STUBDRA__1_224 STUBDRB_0_246
+  STUBDRB_1_230 STUBDRB__0_244 STUBDRB__1_228 STUBDWA_0_248 STUBDWA_1_232
+  STUBDWA__0_250 STUBDWA__1_234 STUBDWB_0_252 STUBDWB_1_236 STUBDWB__0_254
+  STUBDWB__1_238 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI19_0 A0A A0A_ A0B A0B_ BLA_79 BLA_78 BLA_77 BLA_76 BLA__79 BLA__78 BLA__77
+  BLA__76 BLB_79 BLB_78 BLB_77 BLB_76 BLB__79 BLB__78 BLB__77 BLB__76 D_39
+  D_38 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_39 Q_38
+  STUBDRA_0_242 STUBDRA_1_258 STUBDRA__0_240 STUBDRA__1_256 STUBDRB_0_246
+  STUBDRB_1_262 STUBDRB__0_244 STUBDRB__1_260 STUBDWA_0_248 STUBDWA_1_264
+  STUBDWA__0_250 STUBDWA__1_266 STUBDWB_0_252 STUBDWB_1_268 STUBDWB__0_254
+  STUBDWB__1_270 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI1_0 A0A A0A_ A0B A0B_ BLA_7 BLA_6 BLA_5 BLA_4 BLA__7 BLA__6 BLA__5 BLA__4
+  BLB_7 BLB_6 BLB_5 BLB_4 BLB__7 BLB__6 BLB__5 BLB__4 D_3 D_2 GTPA_0 GTPA_1
+  GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_3 Q_2 STUBDRA_0_274 STUBDRA_1_290
+  STUBDRA__0_272 STUBDRA__1_288 STUBDRB_0_278 STUBDRB_1_294 STUBDRB__0_276
+  STUBDRB__1_292 STUBDWA_0_280 STUBDWA_1_296 STUBDWA__0_282 STUBDWA__1_298
+  STUBDWB_0_284 STUBDWB_1_300 STUBDWB__0_286 STUBDWB__1_302 STUBWEA STUBWEB
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31
+  WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41
+  WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51
+  WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61
+  WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39
+  WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49
+  WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59
+  WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1
+  YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD
+  VSS Mem_cnnin2MCOL_MOR4
XI20_0 A0A A0A_ A0B A0B_ BLA_80 BLA_81 BLA_82 BLA_83 BLA__80 BLA__81 BLA__82
+  BLA__83 BLB_80 BLB_81 BLB_82 BLB_83 BLB__80 BLB__81 BLB__82 BLB__83 D_40
+  D_41 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_40 Q_41
+  STUBDRA_0_418 STUBDRA_1_258 STUBDRA__0_416 STUBDRA__1_256 STUBDRB_0_422
+  STUBDRB_1_262 STUBDRB__0_420 STUBDRB__1_260 STUBDWA_0_424 STUBDWA_1_264
+  STUBDWA__0_426 STUBDWA__1_266 STUBDWB_0_428 STUBDWB_1_268 STUBDWB__0_430
+  STUBDWB__1_270 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI21_0 A0A A0A_ A0B A0B_ BLA_87 BLA_86 BLA_85 BLA_84 BLA__87 BLA__86 BLA__85
+  BLA__84 BLB_87 BLB_86 BLB_85 BLB_84 BLB__87 BLB__86 BLB__85 BLB__84 D_43
+  D_42 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_43 Q_42
+  STUBDRA_0_418 STUBDRA_1_434 STUBDRA__0_416 STUBDRA__1_432 STUBDRB_0_422
+  STUBDRB_1_438 STUBDRB__0_420 STUBDRB__1_436 STUBDWA_0_424 STUBDWA_1_440
+  STUBDWA__0_426 STUBDWA__1_442 STUBDWB_0_428 STUBDWB_1_444 STUBDWB__0_430
+  STUBDWB__1_446 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI22_0 A0A A0A_ A0B A0B_ BLA_88 BLA_89 BLA_90 BLA_91 BLA__88 BLA__89 BLA__90
+  BLA__91 BLB_88 BLB_89 BLB_90 BLB_91 BLB__88 BLB__89 BLB__90 BLB__91 D_44
+  D_45 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_44 Q_45
+  STUBDRA_0_450 STUBDRA_1_434 STUBDRA__0_448 STUBDRA__1_432 STUBDRB_0_454
+  STUBDRB_1_438 STUBDRB__0_452 STUBDRB__1_436 STUBDWA_0_456 STUBDWA_1_440
+  STUBDWA__0_458 STUBDWA__1_442 STUBDWB_0_460 STUBDWB_1_444 STUBDWB__0_462
+  STUBDWB__1_446 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI23_0 A0A A0A_ A0B A0B_ BLA_95 BLA_94 BLA_93 BLA_92 BLA__95 BLA__94 BLA__93
+  BLA__92 BLB_95 BLB_94 BLB_93 BLB_92 BLB__95 BLB__94 BLB__93 BLB__92 D_47
+  D_46 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_47 Q_46
+  STUBDRA_0_450 STUBDRA_1_466 STUBDRA__0_448 STUBDRA__1_464 STUBDRB_0_454
+  STUBDRB_1_470 STUBDRB__0_452 STUBDRB__1_468 STUBDWA_0_456 STUBDWA_1_472
+  STUBDWA__0_458 STUBDWA__1_474 STUBDWB_0_460 STUBDWB_1_476 STUBDWB__0_462
+  STUBDWB__1_478 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI24_0 A0A A0A_ A0B A0B_ BLA_96 BLA_97 BLA_98 BLA_99 BLA__96 BLA__97 BLA__98
+  BLA__99 BLB_96 BLB_97 BLB_98 BLB_99 BLB__96 BLB__97 BLB__98 BLB__99 D_48
+  D_49 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_48 Q_49
+  STUBDRA_0_482 STUBDRA_1_466 STUBDRA__0_480 STUBDRA__1_464 STUBDRB_0_486
+  STUBDRB_1_470 STUBDRB__0_484 STUBDRB__1_468 STUBDWA_0_488 STUBDWA_1_472
+  STUBDWA__0_490 STUBDWA__1_474 STUBDWB_0_492 STUBDWB_1_476 STUBDWB__0_494
+  STUBDWB__1_478 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI25_0 A0A A0A_ A0B A0B_ BLA_103 BLA_102 BLA_101 BLA_100 BLA__103 BLA__102
+  BLA__101 BLA__100 BLB_103 BLB_102 BLB_101 BLB_100 BLB__103 BLB__102
+  BLB__101 BLB__100 D_51 D_50 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_51 Q_50 STUBDRA_0_482 STUBDRA_1_18 STUBDRA__0_480 STUBDRA__1_16
+  STUBDRB_0_486 STUBDRB_1_22 STUBDRB__0_484 STUBDRB__1_20 STUBDWA_0_488
+  STUBDWA_1_24 STUBDWA__0_490 STUBDWA__1_26 STUBDWB_0_492 STUBDWB_1_28
+  STUBDWB__0_494 STUBDWB__1_30 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI26_0 A0A A0A_ A0B A0B_ BLA_104 BLA_105 BLA_106 BLA_107 BLA__104 BLA__105
+  BLA__106 BLA__107 BLB_104 BLB_105 BLB_106 BLB_107 BLB__104 BLB__105
+  BLB__106 BLB__107 D_52 D_53 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_52 Q_53 STUBDRA_0_2 STUBDRA_1_18 STUBDRA__0_0 STUBDRA__1_16
+  STUBDRB_0_6 STUBDRB_1_22 STUBDRB__0_4 STUBDRB__1_20 STUBDWA_0_8
+  STUBDWA_1_24 STUBDWA__0_10 STUBDWA__1_26 STUBDWB_0_12 STUBDWB_1_28
+  STUBDWB__0_14 STUBDWB__1_30 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI27_0 A0A A0A_ A0B A0B_ BLA_111 BLA_110 BLA_109 BLA_108 BLA__111 BLA__110
+  BLA__109 BLA__108 BLB_111 BLB_110 BLB_109 BLB_108 BLB__111 BLB__110
+  BLB__109 BLB__108 D_55 D_54 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_55 Q_54 STUBDRA_0_2 STUBDRA_1_34 STUBDRA__0_0 STUBDRA__1_32
+  STUBDRB_0_6 STUBDRB_1_38 STUBDRB__0_4 STUBDRB__1_36 STUBDWA_0_8
+  STUBDWA_1_40 STUBDWA__0_10 STUBDWA__1_42 STUBDWB_0_12 STUBDWB_1_44
+  STUBDWB__0_14 STUBDWB__1_46 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI28_0 A0A A0A_ A0B A0B_ BLA_112 BLA_113 BLA_114 BLA_115 BLA__112 BLA__113
+  BLA__114 BLA__115 BLB_112 BLB_113 BLB_114 BLB_115 BLB__112 BLB__113
+  BLB__114 BLB__115 D_56 D_57 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_56 Q_57 STUBDRA_0_50 STUBDRA_1_34 STUBDRA__0_48 STUBDRA__1_32
+  STUBDRB_0_54 STUBDRB_1_38 STUBDRB__0_52 STUBDRB__1_36 STUBDWA_0_56
+  STUBDWA_1_40 STUBDWA__0_58 STUBDWA__1_42 STUBDWB_0_60 STUBDWB_1_44
+  STUBDWB__0_62 STUBDWB__1_46 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI29_0 A0A A0A_ A0B A0B_ BLA_119 BLA_118 BLA_117 BLA_116 BLA__119 BLA__118
+  BLA__117 BLA__116 BLB_119 BLB_118 BLB_117 BLB_116 BLB__119 BLB__118
+  BLB__117 BLB__116 D_59 D_58 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_59 Q_58 STUBDRA_0_50 STUBDRA_1_66 STUBDRA__0_48 STUBDRA__1_64
+  STUBDRB_0_54 STUBDRB_1_70 STUBDRB__0_52 STUBDRB__1_68 STUBDWA_0_56
+  STUBDWA_1_72 STUBDWA__0_58 STUBDWA__1_74 STUBDWB_0_60 STUBDWB_1_76
+  STUBDWB__0_62 STUBDWB__1_78 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI2_0 A0A A0A_ A0B A0B_ BLA_8 BLA_9 BLA_10 BLA_11 BLA__8 BLA__9 BLA__10
+  BLA__11 BLB_8 BLB_9 BLB_10 BLB_11 BLB__8 BLB__9 BLB__10 BLB__11 D_4 D_5
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_4 Q_5 STUBDRA_0_306
+  STUBDRA_1_290 STUBDRA__0_304 STUBDRA__1_288 STUBDRB_0_310 STUBDRB_1_294
+  STUBDRB__0_308 STUBDRB__1_292 STUBDWA_0_312 STUBDWA_1_296 STUBDWA__0_314
+  STUBDWA__1_298 STUBDWB_0_316 STUBDWB_1_300 STUBDWB__0_318 STUBDWB__1_302
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI30_0 A0A A0A_ A0B A0B_ BLA_120 BLA_121 BLA_122 BLA_123 BLA__120 BLA__121
+  BLA__122 BLA__123 BLB_120 BLB_121 BLB_122 BLB_123 BLB__120 BLB__121
+  BLB__122 BLB__123 D_60 D_61 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_60 Q_61 STUBDRA_0_130 STUBDRA_1_66 STUBDRA__0_128 STUBDRA__1_64
+  STUBDRB_0_134 STUBDRB_1_70 STUBDRB__0_132 STUBDRB__1_68 STUBDWA_0_136
+  STUBDWA_1_72 STUBDWA__0_138 STUBDWA__1_74 STUBDWB_0_140 STUBDWB_1_76
+  STUBDWB__0_142 STUBDWB__1_78 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI31_0 A0A A0A_ A0B A0B_ BLA_127 BLA_126 BLA_125 BLA_124 BLA__127 BLA__126
+  BLA__125 BLA__124 BLB_127 BLB_126 BLB_125 BLB_124 BLB__127 BLB__126
+  BLB__125 BLB__124 D_63 D_62 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_63 Q_62 STUBDRA_0_130 STUBDRA_0 STUBDRA__0_128 STUBDRA__0
+  STUBDRB_0_134 STUBDRB_0 STUBDRB__0_132 STUBDRB__0 STUBDWA_0_136 STUBDWA_0
+  STUBDWA__0_138 STUBDWA__0 STUBDWB_0_140 STUBDWB_0 STUBDWB__0_142 STUBDWB__0
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_ROR4
XI3_0 A0A A0A_ A0B A0B_ BLA_15 BLA_14 BLA_13 BLA_12 BLA__15 BLA__14 BLA__13
+  BLA__12 BLB_15 BLB_14 BLB_13 BLB_12 BLB__15 BLB__14 BLB__13 BLB__12 D_7 D_6
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_7 Q_6 STUBDRA_0_306
+  STUBDRA_1_322 STUBDRA__0_304 STUBDRA__1_320 STUBDRB_0_310 STUBDRB_1_326
+  STUBDRB__0_308 STUBDRB__1_324 STUBDWA_0_312 STUBDWA_1_328 STUBDWA__0_314
+  STUBDWA__1_330 STUBDWB_0_316 STUBDWB_1_332 STUBDWB__0_318 STUBDWB__1_334
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI4_0 A0A A0A_ A0B A0B_ BLA_16 BLA_17 BLA_18 BLA_19 BLA__16 BLA__17 BLA__18
+  BLA__19 BLB_16 BLB_17 BLB_18 BLB_19 BLB__16 BLB__17 BLB__18 BLB__19 D_8 D_9
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_8 Q_9 STUBDRA_0_338
+  STUBDRA_1_322 STUBDRA__0_336 STUBDRA__1_320 STUBDRB_0_342 STUBDRB_1_326
+  STUBDRB__0_340 STUBDRB__1_324 STUBDWA_0_344 STUBDWA_1_328 STUBDWA__0_346
+  STUBDWA__1_330 STUBDWB_0_348 STUBDWB_1_332 STUBDWB__0_350 STUBDWB__1_334
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI5_0 A0A A0A_ A0B A0B_ BLA_23 BLA_22 BLA_21 BLA_20 BLA__23 BLA__22 BLA__21
+  BLA__20 BLB_23 BLB_22 BLB_21 BLB_20 BLB__23 BLB__22 BLB__21 BLB__20 D_11
+  D_10 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_11 Q_10
+  STUBDRA_0_338 STUBDRA_1_354 STUBDRA__0_336 STUBDRA__1_352 STUBDRB_0_342
+  STUBDRB_1_358 STUBDRB__0_340 STUBDRB__1_356 STUBDWA_0_344 STUBDWA_1_360
+  STUBDWA__0_346 STUBDWA__1_362 STUBDWB_0_348 STUBDWB_1_364 STUBDWB__0_350
+  STUBDWB__1_366 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI6_0 A0A A0A_ A0B A0B_ BLA_24 BLA_25 BLA_26 BLA_27 BLA__24 BLA__25 BLA__26
+  BLA__27 BLB_24 BLB_25 BLB_26 BLB_27 BLB__24 BLB__25 BLB__26 BLB__27 D_12
+  D_13 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_12 Q_13
+  STUBDRA_0_370 STUBDRA_1_354 STUBDRA__0_368 STUBDRA__1_352 STUBDRB_0_374
+  STUBDRB_1_358 STUBDRB__0_372 STUBDRB__1_356 STUBDWA_0_376 STUBDWA_1_360
+  STUBDWA__0_378 STUBDWA__1_362 STUBDWB_0_380 STUBDWB_1_364 STUBDWB__0_382
+  STUBDWB__1_366 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI7_0 A0A A0A_ A0B A0B_ BLA_31 BLA_30 BLA_29 BLA_28 BLA__31 BLA__30 BLA__29
+  BLA__28 BLB_31 BLB_30 BLB_29 BLB_28 BLB__31 BLB__30 BLB__29 BLB__28 D_15
+  D_14 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_15 Q_14
+  STUBDRA_0_370 STUBDRA_1_386 STUBDRA__0_368 STUBDRA__1_384 STUBDRB_0_374
+  STUBDRB_1_390 STUBDRB__0_372 STUBDRB__1_388 STUBDWA_0_376 STUBDWA_1_392
+  STUBDWA__0_378 STUBDWA__1_394 STUBDWB_0_380 STUBDWB_1_396 STUBDWB__0_382
+  STUBDWB__1_398 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
XI8_0 A0A A0A_ A0B A0B_ BLA_32 BLA_33 BLA_34 BLA_35 BLA__32 BLA__33 BLA__34
+  BLA__35 BLB_32 BLB_33 BLB_34 BLB_35 BLB__32 BLB__33 BLB__34 BLB__35 D_16
+  D_17 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_16 Q_17
+  STUBDRA_0_402 STUBDRA_1_386 STUBDRA__0_400 STUBDRA__1_384 STUBDRB_0_406
+  STUBDRB_1_390 STUBDRB__0_404 STUBDRB__1_388 STUBDWA_0_408 STUBDWA_1_392
+  STUBDWA__0_410 STUBDWA__1_394 STUBDWB_0_412 STUBDWB_1_396 STUBDWB__0_414
+  STUBDWB__1_398 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MER4
XI9_0 A0A A0A_ A0B A0B_ BLA_39 BLA_38 BLA_37 BLA_36 BLA__39 BLA__38 BLA__37
+  BLA__36 BLB_39 BLB_38 BLB_37 BLB_36 BLB__39 BLB__38 BLB__37 BLB__36 D_19
+  D_18 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_19 Q_18
+  STUBDRA_0_402 STUBDRA_1_98 STUBDRA__0_400 STUBDRA__1_96 STUBDRB_0_406
+  STUBDRB_1_102 STUBDRB__0_404 STUBDRB__1_100 STUBDWA_0_408 STUBDWA_1_104
+  STUBDWA__0_410 STUBDWA__1_106 STUBDWB_0_412 STUBDWB_1_108 STUBDWB__0_414
+  STUBDWB__1_110 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOR4
.ENDS Mem_cnnin2WING_32_RIGHT
****
.SUBCKT Mem_cnnin2FLCIO A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBLA
+  MBLA_ MBLB MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2FLCIO: 22 flat devices **
d1 VSS A0B_ tdndsx AREA=0.1024P PERIM=1.28U
d10 VSS YPB0_0 tdndsx AREA=0.1024P PERIM=1.28U
d11 VSS YPA0_0 tdndsx AREA=0.1024P PERIM=1.28U
d12 VSS YPB1_3 tdndsx AREA=0.1024P PERIM=1.28U
d13 VSS YPA1_3 tdndsx AREA=0.1024P PERIM=1.28U
d14 VSS YPB1_2 tdndsx AREA=0.1024P PERIM=1.28U
d15 VSS YPA1_2 tdndsx AREA=0.1024P PERIM=1.28U
d16 VSS YPB1_1 tdndsx AREA=0.1024P PERIM=1.28U
d17 VSS YPA1_1 tdndsx AREA=0.1024P PERIM=1.28U
d18 VSS YPB1_0 tdndsx AREA=0.1024P PERIM=1.28U
d19 VSS YPA1_0 tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS A0A tdndsx AREA=0.1024P PERIM=1.28U
d20 VSS GTPB tdndsx AREA=0.1024P PERIM=1.28U
d21 VSS GTPA tdndsx AREA=0.1024P PERIM=1.28U
d22 VSS A0B tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS A0A_ tdndsx AREA=0.1024P PERIM=1.28U
d4 VSS YPB0_3 tdndsx AREA=0.1024P PERIM=1.28U
d5 VSS YPA0_3 tdndsx AREA=0.1024P PERIM=1.28U
d6 VSS YPB0_2 tdndsx AREA=0.1024P PERIM=1.28U
d7 VSS YPA0_2 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS YPB0_1 tdndsx AREA=0.1024P PERIM=1.28U
d9 VSS YPA0_1 tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FLCIO
****
.SUBCKT Mem_cnnin2FLCIOX_A A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL
+  MBLA_ MBLB MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2FLCIOX_A: 22 flat devices **
XI0_0 A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBL MBLA_ MBLB MBLB_
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2FLCIO
.ENDS Mem_cnnin2FLCIOX_A
****
.SUBCKT Mem_cnnin2CCMWG BLA BLAD BLA_ BLB BLBD BLB_ WLA WLB VDD VSS
** Mem_cnnin2CCMWG: 8 flat devices **
m1 BLBD WLB CORED VSS lpnfet L=0.13U W=0.16U
m2 N11 WLB CORED_ VSS lpnfet L=0.13U W=0.16U
m3 BLAD WLA CORED VSS lpnfet L=0.13U W=0.16U
m4 N12 WLA CORED_ VSS lpnfet L=0.13U W=0.16U
m5 CORED_ CORED VDD VDD lppfet L=0.12U W=0.16U
m6 CORED_ CORED VSS VSS lpnfet L=0.12U W=0.8U
m7 CORED CORED_ VDD VDD lppfet L=0.12U W=0.16U
m8 CORED CORED_ VSS VSS lpnfet L=0.12U W=0.8U
.ENDS Mem_cnnin2CCMWG
****
.SUBCKT Mem_cnnin2FCIO4 GTPA GTPB OEA_ OEB_ WEA WEB VDD VSS
** Mem_cnnin2FCIO4: 6 flat devices **
d1 VSS WEA tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS GTPB tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS GTPA tdndsx AREA=0.1024P PERIM=1.28U
d4 VSS OEB_ tdndsx AREA=0.1024P PERIM=1.28U
d5 VSS OEA_ tdndsx AREA=0.1024P PERIM=1.28U
d6 VSS WEB tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCIO4
****
.SUBCKT Mem_cnnin2FCSA4 GTPA GTPB VDD VSS
** Mem_cnnin2FCSA4: 2 flat devices **
d1 VSS GTPB tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS GTPA tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCSA4
****
.SUBCKT Mem_cnnin2RIGHT_CAP A0A A0A_ A0B A0B_ GTPA_0 GTPA_1 GTPA_2 GTPB_0
+  GTPB_1 GTPB_2 OEA_ OEB_ WEA WEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2RIGHT_CAP: 544 flat devices **
XI0_0 GTPA_0 GTPB_0 OEA_ OEB_ WEA WEB VDD VSS Mem_cnnin2FCIO4
XI0_1 GTPA_1 GTPB_1 VDD VSS Mem_cnnin2FCSA4
XI0_10 VDD VDD VDD VDD WLA_7 WLB_7 VDD VSS Mem_cnnin2CCG
XI0_11 VDD VDD VDD VDD WLA_8 WLB_8 VDD VSS Mem_cnnin2CCG
XI0_12 VDD VDD VDD VDD WLA_9 WLB_9 VDD VSS Mem_cnnin2CCG
XI0_13 VDD VDD VDD VDD WLA_10 WLB_10 VDD VSS Mem_cnnin2CCG
XI0_14 VDD VDD VDD VDD WLA_11 WLB_11 VDD VSS Mem_cnnin2CCG
XI0_15 VDD VDD VDD VDD WLA_12 WLB_12 VDD VSS Mem_cnnin2CCG
XI0_16 VDD VDD VDD VDD WLA_13 WLB_13 VDD VSS Mem_cnnin2CCG
XI0_17 VDD VDD VDD VDD WLA_14 WLB_14 VDD VSS Mem_cnnin2CCG
XI0_18 VDD VDD VDD VDD WLA_15 WLB_15 VDD VSS Mem_cnnin2CCG
XI0_19 VDD VDD VDD VDD WLA_16 WLB_16 VDD VSS Mem_cnnin2CCG
XI0_20 VDD VDD VDD VDD WLA_17 WLB_17 VDD VSS Mem_cnnin2CCG
XI0_21 VDD VDD VDD VDD WLA_18 WLB_18 VDD VSS Mem_cnnin2CCG
XI0_22 VDD VDD VDD VDD WLA_19 WLB_19 VDD VSS Mem_cnnin2CCG
XI0_23 VDD VDD VDD VDD WLA_20 WLB_20 VDD VSS Mem_cnnin2CCG
XI0_24 VDD VDD VDD VDD WLA_21 WLB_21 VDD VSS Mem_cnnin2CCG
XI0_25 VDD VDD VDD VDD WLA_22 WLB_22 VDD VSS Mem_cnnin2CCG
XI0_26 VDD VDD VDD VDD WLA_23 WLB_23 VDD VSS Mem_cnnin2CCG
XI0_27 VDD VDD VDD VDD WLA_24 WLB_24 VDD VSS Mem_cnnin2CCG
XI0_28 VDD VDD VDD VDD WLA_25 WLB_25 VDD VSS Mem_cnnin2CCG
XI0_29 VDD VDD VDD VDD WLA_26 WLB_26 VDD VSS Mem_cnnin2CCG
XI0_3 VDD VDD VDD VDD WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI0_30 VDD VDD VDD VDD WLA_27 WLB_27 VDD VSS Mem_cnnin2CCG
XI0_31 VDD VDD VDD VDD WLA_28 WLB_28 VDD VSS Mem_cnnin2CCG
XI0_32 VDD VDD VDD VDD WLA_29 WLB_29 VDD VSS Mem_cnnin2CCG
XI0_33 VDD VDD VDD VDD WLA_30 WLB_30 VDD VSS Mem_cnnin2CCG
XI0_34 VDD VDD VDD VDD WLA_31 WLB_31 VDD VSS Mem_cnnin2CCG
XI0_36 VDD VDD VDD VDD WLA_32 WLB_32 VDD VSS Mem_cnnin2CCG
XI0_37 VDD VDD VDD VDD WLA_33 WLB_33 VDD VSS Mem_cnnin2CCG
XI0_38 VDD VDD VDD VDD WLA_34 WLB_34 VDD VSS Mem_cnnin2CCG
XI0_39 VDD VDD VDD VDD WLA_35 WLB_35 VDD VSS Mem_cnnin2CCG
XI0_4 VDD VDD VDD VDD WLA_1 WLB_1 VDD VSS Mem_cnnin2CCG
XI0_40 VDD VDD VDD VDD WLA_36 WLB_36 VDD VSS Mem_cnnin2CCG
XI0_41 VDD VDD VDD VDD WLA_37 WLB_37 VDD VSS Mem_cnnin2CCG
XI0_42 VDD VDD VDD VDD WLA_38 WLB_38 VDD VSS Mem_cnnin2CCG
XI0_43 VDD VDD VDD VDD WLA_39 WLB_39 VDD VSS Mem_cnnin2CCG
XI0_44 VDD VDD VDD VDD WLA_40 WLB_40 VDD VSS Mem_cnnin2CCG
XI0_45 VDD VDD VDD VDD WLA_41 WLB_41 VDD VSS Mem_cnnin2CCG
XI0_46 VDD VDD VDD VDD WLA_42 WLB_42 VDD VSS Mem_cnnin2CCG
XI0_47 VDD VDD VDD VDD WLA_43 WLB_43 VDD VSS Mem_cnnin2CCG
XI0_48 VDD VDD VDD VDD WLA_44 WLB_44 VDD VSS Mem_cnnin2CCG
XI0_49 VDD VDD VDD VDD WLA_45 WLB_45 VDD VSS Mem_cnnin2CCG
XI0_5 VDD VDD VDD VDD WLA_2 WLB_2 VDD VSS Mem_cnnin2CCG
XI0_50 VDD VDD VDD VDD WLA_46 WLB_46 VDD VSS Mem_cnnin2CCG
XI0_51 VDD VDD VDD VDD WLA_47 WLB_47 VDD VSS Mem_cnnin2CCG
XI0_52 VDD VDD VDD VDD WLA_48 WLB_48 VDD VSS Mem_cnnin2CCG
XI0_53 VDD VDD VDD VDD WLA_49 WLB_49 VDD VSS Mem_cnnin2CCG
XI0_54 VDD VDD VDD VDD WLA_50 WLB_50 VDD VSS Mem_cnnin2CCG
XI0_55 VDD VDD VDD VDD WLA_51 WLB_51 VDD VSS Mem_cnnin2CCG
XI0_56 VDD VDD VDD VDD WLA_52 WLB_52 VDD VSS Mem_cnnin2CCG
XI0_57 VDD VDD VDD VDD WLA_53 WLB_53 VDD VSS Mem_cnnin2CCG
XI0_58 VDD VDD VDD VDD WLA_54 WLB_54 VDD VSS Mem_cnnin2CCG
XI0_59 VDD VDD VDD VDD WLA_55 WLB_55 VDD VSS Mem_cnnin2CCG
XI0_6 VDD VDD VDD VDD WLA_3 WLB_3 VDD VSS Mem_cnnin2CCG
XI0_60 VDD VDD VDD VDD WLA_56 WLB_56 VDD VSS Mem_cnnin2CCG
XI0_61 VDD VDD VDD VDD WLA_57 WLB_57 VDD VSS Mem_cnnin2CCG
XI0_62 VDD VDD VDD VDD WLA_58 WLB_58 VDD VSS Mem_cnnin2CCG
XI0_63 VDD VDD VDD VDD WLA_59 WLB_59 VDD VSS Mem_cnnin2CCG
XI0_64 VDD VDD VDD VDD WLA_60 WLB_60 VDD VSS Mem_cnnin2CCG
XI0_65 VDD VDD VDD VDD WLA_61 WLB_61 VDD VSS Mem_cnnin2CCG
XI0_66 VDD VDD VDD VDD WLA_62 WLB_62 VDD VSS Mem_cnnin2CCG
XI0_67 VDD VDD VDD VDD WLA_63 WLB_63 VDD VSS Mem_cnnin2CCG
XI0_68 VDD BLAD VDD VDD BLBD VDD VSS VSS VDD VSS Mem_cnnin2CCMWG
XI0_69 VDD BLAD VDD VDD BLBD VDD VSS VSS VDD VSS Mem_cnnin2CCMWG
XI0_7 VDD VDD VDD VDD WLA_4 WLB_4 VDD VSS Mem_cnnin2CCG
XI0_70 VDD VDD VDD VDD VSS VSS VDD VSS Mem_cnnin2CCG
XI0_8 VDD VDD VDD VDD WLA_5 WLB_5 VDD VSS Mem_cnnin2CCG
XI0_9 VDD VDD VDD VDD WLA_6 WLB_6 VDD VSS Mem_cnnin2CCG
.ENDS Mem_cnnin2RIGHT_CAP
****
.SUBCKT Mem_cnnin2CCMB BLA BLA_ BLB BLB_ WLA WLB VDD VSS
** Mem_cnnin2CCMB: 8 flat devices **
m1 BLB VSS CORED VSS lpnfet L=0.13U W=0.16U
m2 BLB_ VSS CORED_ VSS lpnfet L=0.13U W=0.16U
m3 BLA VSS CORED VSS lpnfet L=0.13U W=0.16U
m4 BLA_ VSS CORED_ VSS lpnfet L=0.13U W=0.16U
m5 CORED_ CORED VDD VDD lppfet L=0.12U W=0.16U
m6 CORED_ CORED VSS VSS lpnfet L=0.12U W=0.8U
m7 CORED CORED_ VDD VDD lppfet L=0.12U W=0.16U
m8 CORED CORED_ VSS VSS lpnfet L=0.12U W=0.8U
.ENDS Mem_cnnin2CCMB
****
.SUBCKT Mem_cnnin2MODEL_COL_A BLA BLA_ MWLAS MWLBD MWLBS MWLD WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDD VSS
** Mem_cnnin2MODEL_COL_A: 512 flat devices **
XI0_0 BLA BLA_ VDD VDD WLA_0 WLB_0 VDD VSS Mem_cnnin2CCMB
XI0_1 BLA BLA_ VDD VDD WLA_1 WLB_1 VDD VSS Mem_cnnin2CCMB
XI0_10 BLA BLA_ VDD VDD WLA_10 WLB_10 VDD VSS Mem_cnnin2CCMB
XI0_11 BLA BLA_ VDD VDD WLA_11 WLB_11 VDD VSS Mem_cnnin2CCMB
XI0_12 BLA BLA_ VDD VDD WLA_12 WLB_12 VDD VSS Mem_cnnin2CCMB
XI0_13 BLA BLA_ VDD VDD WLA_13 WLB_13 VDD VSS Mem_cnnin2CCMB
XI0_14 BLA BLA_ VDD VDD WLA_14 WLB_14 VDD VSS Mem_cnnin2CCMB
XI0_15 BLA BLA_ VDD VDD WLA_15 WLB_15 VDD VSS Mem_cnnin2CCMB
XI0_16 BLA BLA_ VDD VDD WLA_16 WLB_16 VDD VSS Mem_cnnin2CCMB
XI0_17 BLA BLA_ VDD VDD WLA_17 WLB_17 VDD VSS Mem_cnnin2CCMB
XI0_18 BLA BLA_ VDD VDD WLA_18 WLB_18 VDD VSS Mem_cnnin2CCMB
XI0_19 BLA BLA_ VDD VDD WLA_19 WLB_19 VDD VSS Mem_cnnin2CCMB
XI0_2 BLA BLA_ VDD VDD WLA_2 WLB_2 VDD VSS Mem_cnnin2CCMB
XI0_20 BLA BLA_ VDD VDD WLA_20 WLB_20 VDD VSS Mem_cnnin2CCMB
XI0_21 BLA BLA_ VDD VDD WLA_21 WLB_21 VDD VSS Mem_cnnin2CCMB
XI0_22 BLA BLA_ VDD VDD WLA_22 WLB_22 VDD VSS Mem_cnnin2CCMB
XI0_23 BLA BLA_ VDD VDD WLA_23 WLB_23 VDD VSS Mem_cnnin2CCMB
XI0_24 BLA BLA_ VDD VDD WLA_24 WLB_24 VDD VSS Mem_cnnin2CCMB
XI0_25 BLA BLA_ VDD VDD WLA_25 WLB_25 VDD VSS Mem_cnnin2CCMB
XI0_26 BLA BLA_ VDD VDD WLA_26 WLB_26 VDD VSS Mem_cnnin2CCMB
XI0_27 BLA BLA_ VDD VDD WLA_27 WLB_27 VDD VSS Mem_cnnin2CCMB
XI0_28 BLA BLA_ VDD VDD WLA_28 WLB_28 VDD VSS Mem_cnnin2CCMB
XI0_29 BLA BLA_ VDD VDD WLA_29 WLB_29 VDD VSS Mem_cnnin2CCMB
XI0_3 BLA BLA_ VDD VDD WLA_3 WLB_3 VDD VSS Mem_cnnin2CCMB
XI0_30 BLA BLA_ VDD VDD WLA_30 WLB_30 VDD VSS Mem_cnnin2CCMB
XI0_31 BLA BLA_ VDD VDD WLA_31 WLB_31 VDD VSS Mem_cnnin2CCMB
XI0_33 BLA_ BLA VDD VDD WLA_32 WLB_32 VDD VSS Mem_cnnin2CCMB
XI0_34 BLA_ BLA VDD VDD WLA_33 WLB_33 VDD VSS Mem_cnnin2CCMB
XI0_35 BLA_ BLA VDD VDD WLA_34 WLB_34 VDD VSS Mem_cnnin2CCMB
XI0_36 BLA_ BLA VDD VDD WLA_35 WLB_35 VDD VSS Mem_cnnin2CCMB
XI0_37 BLA_ BLA VDD VDD WLA_36 WLB_36 VDD VSS Mem_cnnin2CCMB
XI0_38 BLA_ BLA VDD VDD WLA_37 WLB_37 VDD VSS Mem_cnnin2CCMB
XI0_39 BLA_ BLA VDD VDD WLA_38 WLB_38 VDD VSS Mem_cnnin2CCMB
XI0_4 BLA BLA_ VDD VDD WLA_4 WLB_4 VDD VSS Mem_cnnin2CCMB
XI0_40 BLA_ BLA VDD VDD WLA_39 WLB_39 VDD VSS Mem_cnnin2CCMB
XI0_41 BLA_ BLA VDD VDD WLA_40 WLB_40 VDD VSS Mem_cnnin2CCMB
XI0_42 BLA_ BLA VDD VDD WLA_41 WLB_41 VDD VSS Mem_cnnin2CCMB
XI0_43 BLA_ BLA VDD VDD WLA_42 WLB_42 VDD VSS Mem_cnnin2CCMB
XI0_44 BLA_ BLA VDD VDD WLA_43 WLB_43 VDD VSS Mem_cnnin2CCMB
XI0_45 BLA_ BLA VDD VDD WLA_44 WLB_44 VDD VSS Mem_cnnin2CCMB
XI0_46 BLA_ BLA VDD VDD WLA_45 WLB_45 VDD VSS Mem_cnnin2CCMB
XI0_47 BLA_ BLA VDD VDD WLA_46 WLB_46 VDD VSS Mem_cnnin2CCMB
XI0_48 BLA_ BLA VDD VDD WLA_47 WLB_47 VDD VSS Mem_cnnin2CCMB
XI0_49 BLA_ BLA VDD VDD WLA_48 WLB_48 VDD VSS Mem_cnnin2CCMB
XI0_5 BLA BLA_ VDD VDD WLA_5 WLB_5 VDD VSS Mem_cnnin2CCMB
XI0_50 BLA_ BLA VDD VDD WLA_49 WLB_49 VDD VSS Mem_cnnin2CCMB
XI0_51 BLA_ BLA VDD VDD WLA_50 WLB_50 VDD VSS Mem_cnnin2CCMB
XI0_52 BLA_ BLA VDD VDD WLA_51 WLB_51 VDD VSS Mem_cnnin2CCMB
XI0_53 BLA_ BLA VDD VDD WLA_52 WLB_52 VDD VSS Mem_cnnin2CCMB
XI0_54 BLA_ BLA VDD VDD WLA_53 WLB_53 VDD VSS Mem_cnnin2CCMB
XI0_55 BLA_ BLA VDD VDD WLA_54 WLB_54 VDD VSS Mem_cnnin2CCMB
XI0_56 BLA_ BLA VDD VDD WLA_55 WLB_55 VDD VSS Mem_cnnin2CCMB
XI0_57 BLA_ BLA VDD VDD WLA_56 WLB_56 VDD VSS Mem_cnnin2CCMB
XI0_58 BLA_ BLA VDD VDD WLA_57 WLB_57 VDD VSS Mem_cnnin2CCMB
XI0_59 BLA_ BLA VDD VDD WLA_58 WLB_58 VDD VSS Mem_cnnin2CCMB
XI0_6 BLA BLA_ VDD VDD WLA_6 WLB_6 VDD VSS Mem_cnnin2CCMB
XI0_60 BLA_ BLA VDD VDD WLA_59 WLB_59 VDD VSS Mem_cnnin2CCMB
XI0_61 BLA_ BLA VDD VDD WLA_60 WLB_60 VDD VSS Mem_cnnin2CCMB
XI0_62 BLA_ BLA VDD VDD WLA_61 WLB_61 VDD VSS Mem_cnnin2CCMB
XI0_63 BLA_ BLA VDD VDD WLA_62 WLB_62 VDD VSS Mem_cnnin2CCMB
XI0_64 BLA_ BLA VDD VDD WLA_63 WLB_63 VDD VSS Mem_cnnin2CCMB
XI0_7 BLA BLA_ VDD VDD WLA_7 WLB_7 VDD VSS Mem_cnnin2CCMB
XI0_8 BLA BLA_ VDD VDD WLA_8 WLB_8 VDD VSS Mem_cnnin2CCMB
XI0_9 BLA BLA_ VDD VDD WLA_9 WLB_9 VDD VSS Mem_cnnin2CCMB
.ENDS Mem_cnnin2MODEL_COL_A
****
.SUBCKT Mem_cnnin2CCMWP BLA BLAD BLA_ BLB BLBD BLB_ WLA WLB VDD VSS
** Mem_cnnin2CCMWP: 8 flat devices **
m1 BLBD WLB CORED VSS lpnfet L=0.13U W=0.16U
m2 N11 WLB CORED_ VSS lpnfet L=0.13U W=0.16U
m3 BLAD WLA CORED VSS lpnfet L=0.13U W=0.16U
m4 N12 WLA CORED_ VSS lpnfet L=0.13U W=0.16U
m5 CORED_ CORED VDD VDD lppfet L=0.12U W=0.16U
m6 CORED_ CORED VSS VSS lpnfet L=0.12U W=0.8U
m7 CORED CORED_ VDD VDD lppfet L=0.12U W=0.16U
m8 CORED CORED_ VSS VSS lpnfet L=0.12U W=0.8U
.ENDS Mem_cnnin2CCMWP
****
.SUBCKT Mem_cnnin2FLMWG BLA BLA_ BLB BLB_ MWLA MWLB VDD VSS
** Mem_cnnin2FLMWG: 16 flat devices **
m1 VSS VSS N12 VSS lpnfet L=0.13U W=0.16U
m10 VSS VSS N15 VSS lpnfet L=0.13U W=0.16U
m11 VSS VSS N14 VSS lpnfet L=0.13U W=0.16U
m12 VSS VSS N15 VSS lpnfet L=0.13U W=0.16U
m13 N15 N14 VDD VDD lppfet L=0.12U W=0.16U
m14 N15 N14 VSS VSS lpnfet L=0.12U W=0.8U
m15 N14 N15 VDD VDD lppfet L=0.12U W=0.16U
m16 N14 N15 VSS VSS lpnfet L=0.12U W=0.8U
m2 VSS VSS N13 VSS lpnfet L=0.13U W=0.16U
m3 VSS VSS N12 VSS lpnfet L=0.13U W=0.16U
m4 VSS VSS N13 VSS lpnfet L=0.13U W=0.16U
m5 N13 N12 VDD VDD lppfet L=0.12U W=0.16U
m6 N13 N12 VSS VSS lpnfet L=0.12U W=0.8U
m7 N12 N13 VDD VDD lppfet L=0.12U W=0.16U
m8 N12 N13 VSS VSS lpnfet L=0.12U W=0.8U
m9 VSS VSS N14 VSS lpnfet L=0.13U W=0.16U
.ENDS Mem_cnnin2FLMWG
****
.SUBCKT Mem_cnnin2MODEL_ROW_32 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7
+  BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18
+  BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28
+  BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38
+  BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48
+  BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58
+  BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68
+  BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77 BLA_78
+  BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87 BLA_88
+  BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97 BLA_98
+  BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106 BLA_107
+  BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115 BLA_116
+  BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124 BLA_125
+  BLA_126 BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7
+  BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15 BLA__16
+  BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24 BLA__25
+  BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33 BLA__34
+  BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43
+  BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51 BLA__52
+  BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60 BLA__61
+  BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69 BLA__70
+  BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78 BLA__79
+  BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87 BLA__88
+  BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96 BLA__97
+  BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104 BLA__105
+  BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112 BLA__113
+  BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120 BLA__121
+  BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13
+  BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23
+  BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33
+  BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43
+  BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53
+  BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63
+  BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73
+  BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83
+  BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93
+  BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103
+  BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112
+  BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121
+  BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3
+  BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13
+  BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22
+  BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31
+  BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40
+  BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49
+  BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58
+  BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67
+  BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76
+  BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85
+  BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94
+  BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103
+  BLB__104 BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111
+  BLB__112 BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119
+  BLB__120 BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127
+  WLA_0 WLA_1 WLB_0 WLB_1 VDD VSS
** Mem_cnnin2MODEL_ROW_32: 3072 flat devices **
XI0_0 BLA_0 BLAD_218 BLA__0 BLB_0 BLBD_220 BLB__0 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI0_1 BLA_0 BLAD_218 BLA__0 BLB_0 BLBD_220 BLB__0 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI0_2 BLA_0 BLA__0 BLB_0 BLB__0 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI100_0 BLA_100 BLAD_282 BLA__100 BLB_100 BLBD_284 BLB__100 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI100_1 BLA_100 BLAD_282 BLA__100 BLB_100 BLBD_284 BLB__100 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI100_2 BLA_100 BLA__100 BLB_100 BLB__100 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI101_0 BLA_101 BLAD_410 BLA__101 BLB_101 BLBD_412 BLB__101 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI101_1 BLA_101 BLAD_410 BLA__101 BLB_101 BLBD_412 BLB__101 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI101_2 BLA_101 BLA__101 BLB_101 BLB__101 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI102_0 BLA_102 BLAD_26 BLA__102 BLB_102 BLBD_28 BLB__102 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI102_1 BLA_102 BLAD_26 BLA__102 BLB_102 BLBD_28 BLB__102 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI102_2 BLA_102 BLA__102 BLB_102 BLB__102 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI103_0 BLA_103 BLAD_158 BLA__103 BLB_103 BLBD_160 BLB__103 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI103_1 BLA_103 BLAD_158 BLA__103 BLB_103 BLBD_160 BLB__103 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI103_2 BLA_103 BLA__103 BLB_103 BLB__103 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI104_0 BLA_104 BLAD_290 BLA__104 BLB_104 BLBD_292 BLB__104 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI104_1 BLA_104 BLAD_290 BLA__104 BLB_104 BLBD_292 BLB__104 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI104_2 BLA_104 BLA__104 BLB_104 BLB__104 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI105_0 BLA_105 BLAD_418 BLA__105 BLB_105 BLBD_420 BLB__105 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI105_1 BLA_105 BLAD_418 BLA__105 BLB_105 BLBD_420 BLB__105 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI105_2 BLA_105 BLA__105 BLB_105 BLB__105 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI106_0 BLA_106 BLAD_34 BLA__106 BLB_106 BLBD_36 BLB__106 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI106_1 BLA_106 BLAD_34 BLA__106 BLB_106 BLBD_36 BLB__106 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI106_2 BLA_106 BLA__106 BLB_106 BLB__106 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI107_0 BLA_107 BLAD_166 BLA__107 BLB_107 BLBD_168 BLB__107 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI107_1 BLA_107 BLAD_166 BLA__107 BLB_107 BLBD_168 BLB__107 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI107_2 BLA_107 BLA__107 BLB_107 BLB__107 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI108_0 BLA_108 BLAD_298 BLA__108 BLB_108 BLBD_300 BLB__108 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI108_1 BLA_108 BLAD_298 BLA__108 BLB_108 BLBD_300 BLB__108 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI108_2 BLA_108 BLA__108 BLB_108 BLB__108 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI109_0 BLA_109 BLAD_426 BLA__109 BLB_109 BLBD_428 BLB__109 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI109_1 BLA_109 BLAD_426 BLA__109 BLB_109 BLBD_428 BLB__109 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI109_2 BLA_109 BLA__109 BLB_109 BLB__109 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI10_0 BLA_10 BLAD_42 BLA__10 BLB_10 BLBD_44 BLB__10 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI10_1 BLA_10 BLAD_42 BLA__10 BLB_10 BLBD_44 BLB__10 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI10_2 BLA_10 BLA__10 BLB_10 BLB__10 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI110_0 BLA_110 BLAD_482 BLA__110 BLB_110 BLBD_484 BLB__110 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI110_1 BLA_110 BLAD_482 BLA__110 BLB_110 BLBD_484 BLB__110 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI110_2 BLA_110 BLA__110 BLB_110 BLB__110 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI111_0 BLA_111 BLAD_94 BLA__111 BLB_111 BLBD_96 BLB__111 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI111_1 BLA_111 BLAD_94 BLA__111 BLB_111 BLBD_96 BLB__111 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI111_2 BLA_111 BLA__111 BLB_111 BLB__111 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI112_0 BLA_112 BLAD_230 BLA__112 BLB_112 BLBD_232 BLB__112 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI112_1 BLA_112 BLAD_230 BLA__112 BLB_112 BLBD_232 BLB__112 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI112_2 BLA_112 BLA__112 BLB_112 BLB__112 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI113_0 BLA_113 BLAD_354 BLA__113 BLB_113 BLBD_356 BLB__113 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI113_1 BLA_113 BLAD_354 BLA__113 BLB_113 BLBD_356 BLB__113 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI113_2 BLA_113 BLA__113 BLB_113 BLB__113 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI114_0 BLA_114 BLAD_490 BLA__114 BLB_114 BLBD_492 BLB__114 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI114_1 BLA_114 BLAD_490 BLA__114 BLB_114 BLBD_492 BLB__114 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI114_2 BLA_114 BLA__114 BLB_114 BLB__114 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI115_0 BLA_115 BLAD_102 BLA__115 BLB_115 BLBD_104 BLB__115 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI115_1 BLA_115 BLAD_102 BLA__115 BLB_115 BLBD_104 BLB__115 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI115_2 BLA_115 BLA__115 BLB_115 BLB__115 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI116_0 BLA_116 BLAD_238 BLA__116 BLB_116 BLBD_240 BLB__116 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI116_1 BLA_116 BLAD_238 BLA__116 BLB_116 BLBD_240 BLB__116 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI116_2 BLA_116 BLA__116 BLB_116 BLB__116 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI117_0 BLA_117 BLAD_362 BLA__117 BLB_117 BLBD_364 BLB__117 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI117_1 BLA_117 BLAD_362 BLA__117 BLB_117 BLBD_364 BLB__117 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI117_2 BLA_117 BLA__117 BLB_117 BLB__117 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI118_0 BLA_118 BLAD_494 BLA__118 BLB_118 BLBD_496 BLB__118 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI118_1 BLA_118 BLAD_494 BLA__118 BLB_118 BLBD_496 BLB__118 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI118_2 BLA_118 BLA__118 BLB_118 BLB__118 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI119_0 BLA_119 BLAD_110 BLA__119 BLB_119 BLBD_112 BLB__119 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI119_1 BLA_119 BLAD_110 BLA__119 BLB_119 BLBD_112 BLB__119 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI119_2 BLA_119 BLA__119 BLB_119 BLB__119 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI11_0 BLA_11 BLAD_170 BLA__11 BLB_11 BLBD_172 BLB__11 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI11_1 BLA_11 BLAD_170 BLA__11 BLB_11 BLBD_172 BLB__11 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI11_2 BLA_11 BLA__11 BLB_11 BLB__11 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI120_0 BLA_120 BLAD_154 BLA__120 BLB_120 BLBD_156 BLB__120 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI120_1 BLA_120 BLAD_154 BLA__120 BLB_120 BLBD_156 BLB__120 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI120_2 BLA_120 BLA__120 BLB_120 BLB__120 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI121_0 BLA_121 BLAD_286 BLA__121 BLB_121 BLBD_288 BLB__121 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI121_1 BLA_121 BLAD_286 BLA__121 BLB_121 BLBD_288 BLB__121 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI121_2 BLA_121 BLA__121 BLB_121 BLB__121 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI122_0 BLA_122 BLAD_414 BLA__122 BLB_122 BLBD_416 BLB__122 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI122_1 BLA_122 BLAD_414 BLA__122 BLB_122 BLBD_416 BLB__122 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI122_2 BLA_122 BLA__122 BLB_122 BLB__122 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI123_0 BLA_123 BLAD_30 BLA__123 BLB_123 BLBD_32 BLB__123 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI123_1 BLA_123 BLAD_30 BLA__123 BLB_123 BLBD_32 BLB__123 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI123_2 BLA_123 BLA__123 BLB_123 BLB__123 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI124_0 BLA_124 BLAD_162 BLA__124 BLB_124 BLBD_164 BLB__124 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI124_1 BLA_124 BLAD_162 BLA__124 BLB_124 BLBD_164 BLB__124 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI124_2 BLA_124 BLA__124 BLB_124 BLB__124 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI125_0 BLA_125 BLAD_294 BLA__125 BLB_125 BLBD_296 BLB__125 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI125_1 BLA_125 BLAD_294 BLA__125 BLB_125 BLBD_296 BLB__125 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI125_2 BLA_125 BLA__125 BLB_125 BLB__125 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI126_0 BLA_126 BLAD_422 BLA__126 BLB_126 BLBD_424 BLB__126 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI126_1 BLA_126 BLAD_422 BLA__126 BLB_126 BLBD_424 BLB__126 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI126_2 BLA_126 BLA__126 BLB_126 BLB__126 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI127_0 BLA_127 BLAD_38 BLA__127 BLB_127 BLBD_40 BLB__127 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI127_1 BLA_127 BLAD_38 BLA__127 BLB_127 BLBD_40 BLB__127 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI127_2 BLA_127 BLA__127 BLB_127 BLB__127 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI12_0 BLA_12 BLAD_302 BLA__12 BLB_12 BLBD_304 BLB__12 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI12_1 BLA_12 BLAD_302 BLA__12 BLB_12 BLBD_304 BLB__12 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI12_2 BLA_12 BLA__12 BLB_12 BLB__12 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI13_0 BLA_13 BLAD_434 BLA__13 BLB_13 BLBD_436 BLB__13 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI13_1 BLA_13 BLAD_434 BLA__13 BLB_13 BLBD_436 BLB__13 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI13_2 BLA_13 BLA__13 BLB_13 BLB__13 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI14_0 BLA_14 BLAD_50 BLA__14 BLB_14 BLBD_52 BLB__14 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI14_1 BLA_14 BLAD_50 BLA__14 BLB_14 BLBD_52 BLB__14 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI14_2 BLA_14 BLA__14 BLB_14 BLB__14 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI15_0 BLA_15 BLAD_178 BLA__15 BLB_15 BLBD_180 BLB__15 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI15_1 BLA_15 BLAD_178 BLA__15 BLB_15 BLBD_180 BLB__15 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI15_2 BLA_15 BLA__15 BLB_15 BLB__15 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI16_0 BLA_16 BLAD_314 BLA__16 BLB_16 BLBD_316 BLB__16 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI16_1 BLA_16 BLAD_314 BLA__16 BLB_16 BLBD_316 BLB__16 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI16_2 BLA_16 BLA__16 BLB_16 BLB__16 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI17_0 BLA_17 BLAD_446 BLA__17 BLB_17 BLBD_448 BLB__17 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI17_1 BLA_17 BLAD_446 BLA__17 BLB_17 BLBD_448 BLB__17 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI17_2 BLA_17 BLA__17 BLB_17 BLB__17 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI18_0 BLA_18 BLAD_66 BLA__18 BLB_18 BLBD_68 BLB__18 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI18_1 BLA_18 BLAD_66 BLA__18 BLB_18 BLBD_68 BLB__18 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI18_2 BLA_18 BLA__18 BLB_18 BLB__18 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI19_0 BLA_19 BLAD_194 BLA__19 BLB_19 BLBD_196 BLB__19 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI19_1 BLA_19 BLAD_194 BLA__19 BLB_19 BLBD_196 BLB__19 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI19_2 BLA_19 BLA__19 BLB_19 BLB__19 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI1_0 BLA_1 BLAD_350 BLA__1 BLB_1 BLBD_352 BLB__1 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI1_1 BLA_1 BLAD_350 BLA__1 BLB_1 BLBD_352 BLB__1 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI1_2 BLA_1 BLA__1 BLB_1 BLB__1 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI20_0 BLA_20 BLAD_242 BLA__20 BLB_20 BLBD_244 BLB__20 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI20_1 BLA_20 BLAD_242 BLA__20 BLB_20 BLBD_244 BLB__20 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI20_2 BLA_20 BLA__20 BLB_20 BLB__20 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI21_0 BLA_21 BLAD_370 BLA__21 BLB_21 BLBD_372 BLB__21 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI21_1 BLA_21 BLAD_370 BLA__21 BLB_21 BLBD_372 BLB__21 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI21_2 BLA_21 BLA__21 BLB_21 BLB__21 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI22_0 BLA_22 BLAD_498 BLA__22 BLB_22 BLBD_500 BLB__22 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI22_1 BLA_22 BLAD_498 BLA__22 BLB_22 BLBD_500 BLB__22 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI22_2 BLA_22 BLA__22 BLB_22 BLB__22 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI23_0 BLA_23 BLAD_118 BLA__23 BLB_23 BLBD_120 BLB__23 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI23_1 BLA_23 BLAD_118 BLA__23 BLB_23 BLBD_120 BLB__23 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI23_2 BLA_23 BLA__23 BLB_23 BLB__23 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI24_0 BLA_24 BLAD_250 BLA__24 BLB_24 BLBD_252 BLB__24 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI24_1 BLA_24 BLAD_250 BLA__24 BLB_24 BLBD_252 BLB__24 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI24_2 BLA_24 BLA__24 BLB_24 BLB__24 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI25_0 BLA_25 BLAD_378 BLA__25 BLB_25 BLBD_380 BLB__25 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI25_1 BLA_25 BLAD_378 BLA__25 BLB_25 BLBD_380 BLB__25 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI25_2 BLA_25 BLA__25 BLB_25 BLB__25 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI26_0 BLA_26 BLAD_2 BLA__26 BLB_26 BLBD_4 BLB__26 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI26_1 BLA_26 BLAD_2 BLA__26 BLB_26 BLBD_4 BLB__26 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI26_2 BLA_26 BLA__26 BLB_26 BLB__26 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI27_0 BLA_27 BLAD_130 BLA__27 BLB_27 BLBD_132 BLB__27 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI27_1 BLA_27 BLAD_130 BLA__27 BLB_27 BLBD_132 BLB__27 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI27_2 BLA_27 BLA__27 BLB_27 BLB__27 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI28_0 BLA_28 BLAD_262 BLA__28 BLB_28 BLBD_264 BLB__28 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI28_1 BLA_28 BLAD_262 BLA__28 BLB_28 BLBD_264 BLB__28 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI28_2 BLA_28 BLA__28 BLB_28 BLB__28 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI29_0 BLA_29 BLAD_394 BLA__29 BLB_29 BLBD_396 BLB__29 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI29_1 BLA_29 BLAD_394 BLA__29 BLB_29 BLBD_396 BLB__29 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI29_2 BLA_29 BLA__29 BLB_29 BLB__29 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI2_0 BLA_2 BLAD_478 BLA__2 BLB_2 BLBD_480 BLB__2 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI2_1 BLA_2 BLAD_478 BLA__2 BLB_2 BLBD_480 BLB__2 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI2_2 BLA_2 BLA__2 BLB_2 BLB__2 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI30_0 BLA_30 BLAD_430 BLA__30 BLB_30 BLBD_432 BLB__30 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI30_1 BLA_30 BLAD_430 BLA__30 BLB_30 BLBD_432 BLB__30 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI30_2 BLA_30 BLA__30 BLB_30 BLB__30 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI31_0 BLA_31 BLAD_46 BLA__31 BLB_31 BLBD_48 BLB__31 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI31_1 BLA_31 BLAD_46 BLA__31 BLB_31 BLBD_48 BLB__31 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI31_2 BLA_31 BLA__31 BLB_31 BLB__31 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI32_0 BLA_32 BLAD_174 BLA__32 BLB_32 BLBD_176 BLB__32 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI32_1 BLA_32 BLAD_174 BLA__32 BLB_32 BLBD_176 BLB__32 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI32_2 BLA_32 BLA__32 BLB_32 BLB__32 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI33_0 BLA_33 BLAD_310 BLA__33 BLB_33 BLBD_312 BLB__33 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI33_1 BLA_33 BLAD_310 BLA__33 BLB_33 BLBD_312 BLB__33 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI33_2 BLA_33 BLA__33 BLB_33 BLB__33 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI34_0 BLA_34 BLAD_442 BLA__34 BLB_34 BLBD_444 BLB__34 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI34_1 BLA_34 BLAD_442 BLA__34 BLB_34 BLBD_444 BLB__34 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI34_2 BLA_34 BLA__34 BLB_34 BLB__34 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI35_0 BLA_35 BLAD_58 BLA__35 BLB_35 BLBD_60 BLB__35 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI35_1 BLA_35 BLAD_58 BLA__35 BLB_35 BLBD_60 BLB__35 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI35_2 BLA_35 BLA__35 BLB_35 BLB__35 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI36_0 BLA_36 BLAD_190 BLA__36 BLB_36 BLBD_192 BLB__36 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI36_1 BLA_36 BLAD_190 BLA__36 BLB_36 BLBD_192 BLB__36 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI36_2 BLA_36 BLA__36 BLB_36 BLB__36 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI37_0 BLA_37 BLAD_326 BLA__37 BLB_37 BLBD_328 BLB__37 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI37_1 BLA_37 BLAD_326 BLA__37 BLB_37 BLBD_328 BLB__37 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI37_2 BLA_37 BLA__37 BLB_37 BLB__37 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI38_0 BLA_38 BLAD_458 BLA__38 BLB_38 BLBD_460 BLB__38 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI38_1 BLA_38 BLAD_458 BLA__38 BLB_38 BLBD_460 BLB__38 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI38_2 BLA_38 BLA__38 BLB_38 BLB__38 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI39_0 BLA_39 BLAD_78 BLA__39 BLB_39 BLBD_80 BLB__39 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI39_1 BLA_39 BLAD_78 BLA__39 BLB_39 BLBD_80 BLB__39 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI39_2 BLA_39 BLA__39 BLB_39 BLB__39 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI3_0 BLA_3 BLAD_98 BLA__3 BLB_3 BLBD_100 BLB__3 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI3_1 BLA_3 BLAD_98 BLA__3 BLB_3 BLBD_100 BLB__3 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI3_2 BLA_3 BLA__3 BLB_3 BLB__3 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI40_0 BLA_40 BLAD_114 BLA__40 BLB_40 BLBD_116 BLB__40 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI40_1 BLA_40 BLAD_114 BLA__40 BLB_40 BLBD_116 BLB__40 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI40_2 BLA_40 BLA__40 BLB_40 BLB__40 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI41_0 BLA_41 BLAD_246 BLA__41 BLB_41 BLBD_248 BLB__41 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI41_1 BLA_41 BLAD_246 BLA__41 BLB_41 BLBD_248 BLB__41 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI41_2 BLA_41 BLA__41 BLB_41 BLB__41 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI42_0 BLA_42 BLAD_374 BLA__42 BLB_42 BLBD_376 BLB__42 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI42_1 BLA_42 BLAD_374 BLA__42 BLB_42 BLBD_376 BLB__42 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI42_2 BLA_42 BLA__42 BLB_42 BLB__42 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI43_0 BLA_43 BLAD BLA__43 BLB_43 BLBD BLB__43 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI43_1 BLA_43 BLAD BLA__43 BLB_43 BLBD BLB__43 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI43_2 BLA_43 BLA__43 BLB_43 BLB__43 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI44_0 BLA_44 BLAD_126 BLA__44 BLB_44 BLBD_128 BLB__44 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI44_1 BLA_44 BLAD_126 BLA__44 BLB_44 BLBD_128 BLB__44 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI44_2 BLA_44 BLA__44 BLB_44 BLB__44 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI45_0 BLA_45 BLAD_258 BLA__45 BLB_45 BLBD_260 BLB__45 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI45_1 BLA_45 BLAD_258 BLA__45 BLB_45 BLBD_260 BLB__45 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI45_2 BLA_45 BLA__45 BLB_45 BLB__45 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI46_0 BLA_46 BLAD_390 BLA__46 BLB_46 BLBD_392 BLB__46 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI46_1 BLA_46 BLAD_390 BLA__46 BLB_46 BLBD_392 BLB__46 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI46_2 BLA_46 BLA__46 BLB_46 BLB__46 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI47_0 BLA_47 BLAD_10 BLA__47 BLB_47 BLBD_12 BLB__47 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI47_1 BLA_47 BLAD_10 BLA__47 BLB_47 BLBD_12 BLB__47 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI47_2 BLA_47 BLA__47 BLB_47 BLB__47 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI48_0 BLA_48 BLAD_142 BLA__48 BLB_48 BLBD_144 BLB__48 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI48_1 BLA_48 BLAD_142 BLA__48 BLB_48 BLBD_144 BLB__48 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI48_2 BLA_48 BLA__48 BLB_48 BLB__48 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI49_0 BLA_49 BLAD_274 BLA__49 BLB_49 BLBD_276 BLB__49 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI49_1 BLA_49 BLAD_274 BLA__49 BLB_49 BLBD_276 BLB__49 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI49_2 BLA_49 BLA__49 BLB_49 BLB__49 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI4_0 BLA_4 BLAD_226 BLA__4 BLB_4 BLBD_228 BLB__4 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI4_1 BLA_4 BLAD_226 BLA__4 BLB_4 BLBD_228 BLB__4 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI4_2 BLA_4 BLA__4 BLB_4 BLB__4 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI50_0 BLA_50 BLAD_306 BLA__50 BLB_50 BLBD_308 BLB__50 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI50_1 BLA_50 BLAD_306 BLA__50 BLB_50 BLBD_308 BLB__50 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI50_2 BLA_50 BLA__50 BLB_50 BLB__50 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI51_0 BLA_51 BLAD_438 BLA__51 BLB_51 BLBD_440 BLB__51 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI51_1 BLA_51 BLAD_438 BLA__51 BLB_51 BLBD_440 BLB__51 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI51_2 BLA_51 BLA__51 BLB_51 BLB__51 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI52_0 BLA_52 BLAD_54 BLA__52 BLB_52 BLBD_56 BLB__52 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI52_1 BLA_52 BLAD_54 BLA__52 BLB_52 BLBD_56 BLB__52 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI52_2 BLA_52 BLA__52 BLB_52 BLB__52 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI53_0 BLA_53 BLAD_186 BLA__53 BLB_53 BLBD_188 BLB__53 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI53_1 BLA_53 BLAD_186 BLA__53 BLB_53 BLBD_188 BLB__53 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI53_2 BLA_53 BLA__53 BLB_53 BLB__53 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI54_0 BLA_54 BLAD_322 BLA__54 BLB_54 BLBD_324 BLB__54 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI54_1 BLA_54 BLAD_322 BLA__54 BLB_54 BLBD_324 BLB__54 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI54_2 BLA_54 BLA__54 BLB_54 BLB__54 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI55_0 BLA_55 BLAD_454 BLA__55 BLB_55 BLBD_456 BLB__55 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI55_1 BLA_55 BLAD_454 BLA__55 BLB_55 BLBD_456 BLB__55 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI55_2 BLA_55 BLA__55 BLB_55 BLB__55 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI56_0 BLA_56 BLAD_74 BLA__56 BLB_56 BLBD_76 BLB__56 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI56_1 BLA_56 BLAD_74 BLA__56 BLB_56 BLBD_76 BLB__56 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI56_2 BLA_56 BLA__56 BLB_56 BLB__56 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI57_0 BLA_57 BLAD_206 BLA__57 BLB_57 BLBD_208 BLB__57 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI57_1 BLA_57 BLAD_206 BLA__57 BLB_57 BLBD_208 BLB__57 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI57_2 BLA_57 BLA__57 BLB_57 BLB__57 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI58_0 BLA_58 BLAD_338 BLA__58 BLB_58 BLBD_340 BLB__58 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI58_1 BLA_58 BLAD_338 BLA__58 BLB_58 BLBD_340 BLB__58 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI58_2 BLA_58 BLA__58 BLB_58 BLB__58 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI59_0 BLA_59 BLAD_470 BLA__59 BLB_59 BLBD_472 BLB__59 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI59_1 BLA_59 BLAD_470 BLA__59 BLB_59 BLBD_472 BLB__59 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI59_2 BLA_59 BLA__59 BLB_59 BLB__59 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI5_0 BLA_5 BLAD_358 BLA__5 BLB_5 BLBD_360 BLB__5 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI5_1 BLA_5 BLAD_358 BLA__5 BLB_5 BLBD_360 BLB__5 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI5_2 BLA_5 BLA__5 BLB_5 BLB__5 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI60_0 BLA_60 BLAD_502 BLA__60 BLB_60 BLBD_504 BLB__60 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI60_1 BLA_60 BLAD_502 BLA__60 BLB_60 BLBD_504 BLB__60 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI60_2 BLA_60 BLA__60 BLB_60 BLB__60 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI61_0 BLA_61 BLAD_122 BLA__61 BLB_61 BLBD_124 BLB__61 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI61_1 BLA_61 BLAD_122 BLA__61 BLB_61 BLBD_124 BLB__61 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI61_2 BLA_61 BLA__61 BLB_61 BLB__61 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI62_0 BLA_62 BLAD_254 BLA__62 BLB_62 BLBD_256 BLB__62 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI62_1 BLA_62 BLAD_254 BLA__62 BLB_62 BLBD_256 BLB__62 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI62_2 BLA_62 BLA__62 BLB_62 BLB__62 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI63_0 BLA_63 BLAD_386 BLA__63 BLB_63 BLBD_388 BLB__63 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI63_1 BLA_63 BLAD_386 BLA__63 BLB_63 BLBD_388 BLB__63 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI63_2 BLA_63 BLA__63 BLB_63 BLB__63 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI64_0 BLA_64 BLA__64 BLB_64 BLB__64 WLA_1 WLB_1 VDD VSS Mem_cnnin2FLMWG
XI64_2 BLA_64 BLA__64 BLB_64 BLB__64 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI65_0 BLA_65 BLAD_138 BLA__65 BLB_65 BLBD_140 BLB__65 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI65_1 BLA_65 BLAD_138 BLA__65 BLB_65 BLBD_140 BLB__65 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI65_2 BLA_65 BLA__65 BLB_65 BLB__65 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI66_0 BLA_66 BLAD_270 BLA__66 BLB_66 BLBD_272 BLB__66 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI66_1 BLA_66 BLAD_270 BLA__66 BLB_66 BLBD_272 BLB__66 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI66_2 BLA_66 BLA__66 BLB_66 BLB__66 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI67_0 BLA_67 BLAD_402 BLA__67 BLB_67 BLBD_404 BLB__67 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI67_1 BLA_67 BLAD_402 BLA__67 BLB_67 BLBD_404 BLB__67 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI67_2 BLA_67 BLA__67 BLB_67 BLB__67 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI68_0 BLA_68 BLAD_18 BLA__68 BLB_68 BLBD_20 BLB__68 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI68_1 BLA_68 BLAD_18 BLA__68 BLB_68 BLBD_20 BLB__68 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI68_2 BLA_68 BLA__68 BLB_68 BLB__68 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI69_0 BLA_69 BLAD_150 BLA__69 BLB_69 BLBD_152 BLB__69 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI69_1 BLA_69 BLAD_150 BLA__69 BLB_69 BLBD_152 BLB__69 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI69_2 BLA_69 BLA__69 BLB_69 BLB__69 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI6_0 BLA_6 BLAD_486 BLA__6 BLB_6 BLBD_488 BLB__6 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI6_1 BLA_6 BLAD_486 BLA__6 BLB_6 BLBD_488 BLB__6 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI6_2 BLA_6 BLA__6 BLB_6 BLB__6 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI70_0 BLA_70 BLAD_182 BLA__70 BLB_70 BLBD_184 BLB__70 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI70_1 BLA_70 BLAD_182 BLA__70 BLB_70 BLBD_184 BLB__70 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI70_2 BLA_70 BLA__70 BLB_70 BLB__70 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI71_0 BLA_71 BLAD_318 BLA__71 BLB_71 BLBD_320 BLB__71 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI71_1 BLA_71 BLAD_318 BLA__71 BLB_71 BLBD_320 BLB__71 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI71_2 BLA_71 BLA__71 BLB_71 BLB__71 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI72_0 BLA_72 BLAD_450 BLA__72 BLB_72 BLBD_452 BLB__72 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI72_1 BLA_72 BLAD_450 BLA__72 BLB_72 BLBD_452 BLB__72 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI72_2 BLA_72 BLA__72 BLB_72 BLB__72 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI73_0 BLA_73 BLAD_70 BLA__73 BLB_73 BLBD_72 BLB__73 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI73_1 BLA_73 BLAD_70 BLA__73 BLB_73 BLBD_72 BLB__73 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI73_2 BLA_73 BLA__73 BLB_73 BLB__73 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI74_0 BLA_74 BLAD_202 BLA__74 BLB_74 BLBD_204 BLB__74 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI74_1 BLA_74 BLAD_202 BLA__74 BLB_74 BLBD_204 BLB__74 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI74_2 BLA_74 BLA__74 BLB_74 BLB__74 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI75_0 BLA_75 BLAD_334 BLA__75 BLB_75 BLBD_336 BLB__75 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI75_1 BLA_75 BLAD_334 BLA__75 BLB_75 BLBD_336 BLB__75 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI75_2 BLA_75 BLA__75 BLB_75 BLB__75 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI76_0 BLA_76 BLAD_466 BLA__76 BLB_76 BLBD_468 BLB__76 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI76_1 BLA_76 BLAD_466 BLA__76 BLB_76 BLBD_468 BLB__76 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI76_2 BLA_76 BLA__76 BLB_76 BLB__76 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI77_0 BLA_77 BLAD_86 BLA__77 BLB_77 BLBD_88 BLB__77 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI77_1 BLA_77 BLAD_86 BLA__77 BLB_77 BLBD_88 BLB__77 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI77_2 BLA_77 BLA__77 BLB_77 BLB__77 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI78_0 BLA_78 BLAD_214 BLA__78 BLB_78 BLBD_216 BLB__78 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI78_1 BLA_78 BLAD_214 BLA__78 BLB_78 BLBD_216 BLB__78 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI78_2 BLA_78 BLA__78 BLB_78 BLB__78 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI79_0 BLA_79 BLAD_346 BLA__79 BLB_79 BLBD_348 BLB__79 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI79_1 BLA_79 BLAD_346 BLA__79 BLB_79 BLBD_348 BLB__79 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI79_2 BLA_79 BLA__79 BLB_79 BLB__79 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI7_0 BLA_7 BLAD_106 BLA__7 BLB_7 BLBD_108 BLB__7 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI7_1 BLA_7 BLAD_106 BLA__7 BLB_7 BLBD_108 BLB__7 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI7_2 BLA_7 BLA__7 BLB_7 BLB__7 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI80_0 BLA_80 BLAD_382 BLA__80 BLB_80 BLBD_384 BLB__80 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI80_1 BLA_80 BLAD_382 BLA__80 BLB_80 BLBD_384 BLB__80 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI80_2 BLA_80 BLA__80 BLB_80 BLB__80 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI81_0 BLA_81 BLAD_6 BLA__81 BLB_81 BLBD_8 BLB__81 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI81_1 BLA_81 BLAD_6 BLA__81 BLB_81 BLBD_8 BLB__81 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI81_2 BLA_81 BLA__81 BLB_81 BLB__81 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI82_0 BLA_82 BLAD_134 BLA__82 BLB_82 BLBD_136 BLB__82 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI82_1 BLA_82 BLAD_134 BLA__82 BLB_82 BLBD_136 BLB__82 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI82_2 BLA_82 BLA__82 BLB_82 BLB__82 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI83_0 BLA_83 BLAD_266 BLA__83 BLB_83 BLBD_268 BLB__83 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI83_1 BLA_83 BLAD_266 BLA__83 BLB_83 BLBD_268 BLB__83 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI83_2 BLA_83 BLA__83 BLB_83 BLB__83 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI84_0 BLA_84 BLAD_398 BLA__84 BLB_84 BLBD_400 BLB__84 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI84_1 BLA_84 BLAD_398 BLA__84 BLB_84 BLBD_400 BLB__84 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI84_2 BLA_84 BLA__84 BLB_84 BLB__84 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI85_0 BLA_85 BLAD_14 BLA__85 BLB_85 BLBD_16 BLB__85 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI85_1 BLA_85 BLAD_14 BLA__85 BLB_85 BLBD_16 BLB__85 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI85_2 BLA_85 BLA__85 BLB_85 BLB__85 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI86_0 BLA_86 BLAD_146 BLA__86 BLB_86 BLBD_148 BLB__86 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI86_1 BLA_86 BLAD_146 BLA__86 BLB_86 BLBD_148 BLB__86 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI86_2 BLA_86 BLA__86 BLB_86 BLB__86 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI87_0 BLA_87 BLAD_278 BLA__87 BLB_87 BLBD_280 BLB__87 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI87_1 BLA_87 BLAD_278 BLA__87 BLB_87 BLBD_280 BLB__87 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI87_2 BLA_87 BLA__87 BLB_87 BLB__87 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI88_0 BLA_88 BLAD_406 BLA__88 BLB_88 BLBD_408 BLB__88 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI88_1 BLA_88 BLAD_406 BLA__88 BLB_88 BLBD_408 BLB__88 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI88_2 BLA_88 BLA__88 BLB_88 BLB__88 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI89_0 BLA_89 BLAD_22 BLA__89 BLB_89 BLBD_24 BLB__89 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI89_1 BLA_89 BLAD_22 BLA__89 BLB_89 BLBD_24 BLB__89 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI89_2 BLA_89 BLA__89 BLB_89 BLB__89 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI8_0 BLA_8 BLAD_234 BLA__8 BLB_8 BLBD_236 BLB__8 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI8_1 BLA_8 BLAD_234 BLA__8 BLB_8 BLBD_236 BLB__8 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWG
XI8_2 BLA_8 BLA__8 BLB_8 BLB__8 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI90_0 BLA_90 BLAD_62 BLA__90 BLB_90 BLBD_64 BLB__90 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI90_1 BLA_90 BLAD_62 BLA__90 BLB_90 BLBD_64 BLB__90 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI90_2 BLA_90 BLA__90 BLB_90 BLB__90 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI91_0 BLA_91 BLAD_198 BLA__91 BLB_91 BLBD_200 BLB__91 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI91_1 BLA_91 BLAD_198 BLA__91 BLB_91 BLBD_200 BLB__91 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI91_2 BLA_91 BLA__91 BLB_91 BLB__91 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI92_0 BLA_92 BLAD_330 BLA__92 BLB_92 BLBD_332 BLB__92 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI92_1 BLA_92 BLAD_330 BLA__92 BLB_92 BLBD_332 BLB__92 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI92_2 BLA_92 BLA__92 BLB_92 BLB__92 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI93_0 BLA_93 BLAD_462 BLA__93 BLB_93 BLBD_464 BLB__93 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI93_1 BLA_93 BLAD_462 BLA__93 BLB_93 BLBD_464 BLB__93 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI93_2 BLA_93 BLA__93 BLB_93 BLB__93 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI94_0 BLA_94 BLAD_82 BLA__94 BLB_94 BLBD_84 BLB__94 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI94_1 BLA_94 BLAD_82 BLA__94 BLB_94 BLBD_84 BLB__94 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI94_2 BLA_94 BLA__94 BLB_94 BLB__94 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI95_0 BLA_95 BLAD_210 BLA__95 BLB_95 BLBD_212 BLB__95 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI95_1 BLA_95 BLAD_210 BLA__95 BLB_95 BLBD_212 BLB__95 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI95_2 BLA_95 BLA__95 BLB_95 BLB__95 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI96_0 BLA_96 BLAD_342 BLA__96 BLB_96 BLBD_344 BLB__96 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI96_1 BLA_96 BLAD_342 BLA__96 BLB_96 BLBD_344 BLB__96 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI96_2 BLA_96 BLA__96 BLB_96 BLB__96 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI97_0 BLA_97 BLAD_474 BLA__97 BLB_97 BLBD_476 BLB__97 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI97_1 BLA_97 BLAD_474 BLA__97 BLB_97 BLBD_476 BLB__97 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI97_2 BLA_97 BLA__97 BLB_97 BLB__97 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI98_0 BLA_98 BLAD_90 BLA__98 BLB_98 BLBD_92 BLB__98 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI98_1 BLA_98 BLAD_90 BLA__98 BLB_98 BLBD_92 BLB__98 VSS VSS VDD VSS
+  Mem_cnnin2CCMWP
XI98_2 BLA_98 BLA__98 BLB_98 BLB__98 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
XI99_0 BLA_99 BLAD_222 BLA__99 BLB_99 BLBD_224 BLB__99 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI99_1 BLA_99 BLAD_222 BLA__99 BLB_99 BLBD_224 BLB__99 VSS VSS VDD VSS
+  Mem_cnnin2CCMWG
XI99_2 BLA_99 BLA__99 BLB_99 BLB__99 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCG
XI9_0 BLA_9 BLAD_366 BLA__9 BLB_9 BLBD_368 BLB__9 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI9_1 BLA_9 BLAD_366 BLA__9 BLB_9 BLBD_368 BLB__9 WLA_1 WLB_1 VDD VSS
+  Mem_cnnin2CCMWP
XI9_2 BLA_9 BLA__9 BLB_9 BLB__9 WLA_0 WLB_0 VDD VSS Mem_cnnin2CCP
.ENDS Mem_cnnin2MODEL_ROW_32
****
.SUBCKT Mem_cnnin2MXCD_ODD_LEFT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ DRSA_0 DRSA_1
+  DRSA_2 DRSA_3 DWSA_0 DWSA_1 DWSA_2 DWSA_3 GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MXCD_ODD_LEFT: 188 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA2 BLA2_ BLA3 BLA3_ DRSA_0 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_0 DRSA_1 DWSA_0 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_0
+  DWSA_1 YPA0_1 VDD GTPA GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI1_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB2 BLB2_ BLB3 BLB3_ DRSA_3 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_1 DRSA_2 DWSA_3 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_1
+  DWSA_2 YPB0_1 VDD GTPB GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI2_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB0 BLB0_ BLB1 BLB1_ DRSA_3 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_2 DRSA_2 DWSA_3 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_2
+  DWSA_2 YPB0_0 VDD GTPB GTPA GTPB DRSA_0 DRSA_1 DRSA_3 DRSA_2 DWSA_0 DWSA_1
+  DWSA_3 DWSA_2 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI3_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA0 BLA0_ BLA1 BLA1_ DRSA_0 DRSA_0 DRSA_1
+  DRSA_3 DRSA_2 DRSA_3 DRSA_1 DWSA_0 DWSA_0 DWSA_1 DWSA_3 DWSA_2 DWSA_3
+  DWSA_1 YPA0_0 VDD GTPA GTPA GTPB STUBDRA STUBDRA_ STUBDRB STUBDRB_ STUBDWA
+  STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
.ENDS Mem_cnnin2MXCD_ODD_LEFT
****
.SUBCKT Mem_cnnin2MCOL_MOL4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_MOL4: 2438 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWM4A
XI0_1 D_0 DPN DPU STUBDWA_1 STUBDWA__1 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_1 STUBDRA__1 STUBDWA_1 STUBDWA__1 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__3 BLA_3 BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0
+  BLB__3 BLB_3 BLB__2 BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 STUBDRA_1 STUBDRA__1
+  STUBDRB__1 STUBDRB_1 STUBDWA_1 STUBDWA__1 STUBDWB__1 STUBDWB_1 GTPA_2
+  GTPB_2 STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_ODD_LEFT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_1 STUBDWB__1 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_1 STUBDRB__1 STUBDWB_1 STUBDWB__1 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_MOL4
****
.SUBCKT Mem_cnnin2MXCD_EVEN_LEFT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ GTPA GTPB
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MXCD_EVEN_LEFT: 188 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA0 BLA0_ BLA1 BLA1_ STUBDRA_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWA_0 STUBDWA__0 YPA0_0 VDD GTPA GTPA
+  GTPB STUBDRA_1 STUBDRA__1 STUBDRB_1 STUBDRB__1 STUBDWA_1 STUBDWA__1
+  STUBDWB_1 STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI1_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB0 BLB0_ BLB1 BLB1_ STUBDRB_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRA__0 STUBDRB__0 STUBDWB_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWA__0 STUBDWB__0 YPB0_0 VDD GTPB GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI2_0 A0B A0A A0A_ A0B A0B_ A0B_ BLB2 BLB2_ BLB3 BLB3_ STUBDRB_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRB__0 STUBDRB__0 STUBDWB_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWB__0 STUBDWB__0 YPB0_1 VDD GTPB GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
XI3_0 A0A A0A A0A_ A0B A0B_ A0A_ BLA2 BLA2_ BLA3 BLA3_ STUBDRA_0 STUBDRA_0
+  STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDRB_0 STUBDRA__0 STUBDWA_0 STUBDWA_0
+  STUBDWA__0 STUBDWB_0 STUBDWB__0 STUBDWB_0 STUBDWA__0 YPA0_1 VDD GTPA GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2CD
.ENDS Mem_cnnin2MXCD_EVEN_LEFT
****
.SUBCKT Mem_cnnin2MCOL_MEL4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_MEL4: 2438 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWM4A
XI0_1 D_0 DPN DPU STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLA__3 BLA_3
+  BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 BLB__3 BLB_3 GTPA_2 GTPB_2 STUBDRA_0
+  STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0 STUBDRB__1
+  STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1 STUBDWB__0
+  STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_EVEN_LEFT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_MEL4
****
.SUBCKT Mem_cnnin2FCBWLE4 BWEN BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWLE4: 3 flat devices **
d1 VSS Q tdndsx AREA=0.2116P PERIM=1.84U
d2 VSS BWENA tdndsx AREA=0.2116P PERIM=1.84U
d3 VSS D tdndsx AREA=0.2116P PERIM=1.84U
.ENDS Mem_cnnin2FCBWLE4
****
.SUBCKT Mem_cnnin2FCBWLE4A BWENA BWENB D Q VDD VSS
** Mem_cnnin2FCBWLE4A: 3 flat devices **
XI0_0 BWENA BWENA BWENB D Q VDD VSS Mem_cnnin2FCBWLE4
.ENDS Mem_cnnin2FCBWLE4A
****
.SUBCKT Mem_cnnin2MCOL_LEL4 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0
+  BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3
+  D_0 D_1 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2MCOL_LEL4: 2439 flat devices **
XI0_0 VSS VSS D_0 Q_0 VDD VSS Mem_cnnin2FCBWLE4A
XI0_1 D_0 DPN DPU STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_0 SP STUBWEA
+  STUBWEB VDD VSS Mem_cnnin2IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_1 GTPB_1 SP VDD
+  VSS Mem_cnnin2SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLA__3 BLA_3
+  BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 BLB__3 BLB_3 GTPA_2 GTPB_2 STUBDRA_0
+  STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0 STUBDRB__1
+  STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1 STUBDWB__0
+  STUBDWB__1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2MXCD_EVEN_LEFT
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3 BLB_0 BLB_1 BLB_2
+  BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2BIT_COL
XI1_0 VSS VSS D_1 Q_1 VDD VSS Mem_cnnin2FCBWM4B
XI1_1 D_1 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 OEA_ OEB_ Q_1 SP_3
+  STUBWEA STUBWEB VDD VSS Mem_cnnin2IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_1 GTPB_1 SP_3
+  VDD VSS Mem_cnnin2SAX_B
.ENDS Mem_cnnin2MCOL_LEL4
****
.SUBCKT Mem_cnnin2WING_32_LEFT A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4
+  BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15
+  BLA_16 BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25
+  BLA_26 BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35
+  BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45
+  BLA_46 BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55
+  BLA_56 BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65
+  BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75
+  BLA_76 BLA_77 BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85
+  BLA_86 BLA_87 BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95
+  BLA_96 BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105
+  BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114
+  BLA_115 BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123
+  BLA_124 BLA_125 BLA_126 BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1
+  BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13
+  BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23
+  BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33
+  BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43
+  BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53
+  BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63
+  BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73
+  BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83
+  BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93
+  BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103
+  BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112
+  BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121
+  BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3
+  BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13
+  BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22
+  BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31
+  BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40
+  BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49
+  BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58
+  BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67
+  BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76
+  BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85
+  BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94
+  BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103
+  BLB__104 BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111
+  BLB__112 BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119
+  BLB__120 BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127 D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 D_16 D_17
+  D_18 D_19 D_20 D_21 D_22 D_23 D_24 D_25 D_26 D_27 D_28 D_29 D_30 D_31 D_32
+  D_33 D_34 D_35 D_36 D_37 D_38 D_39 D_40 D_41 D_42 D_43 D_44 D_45 D_46 D_47
+  D_48 D_49 D_50 D_51 D_52 D_53 D_54 D_55 D_56 D_57 D_58 D_59 D_60 D_61 D_62
+  D_63 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17 Q_18 Q_19
+  Q_20 Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28 Q_29 Q_30 Q_31 Q_32 Q_33 Q_34
+  Q_35 Q_36 Q_37 Q_38 Q_39 Q_40 Q_41 Q_42 Q_43 Q_44 Q_45 Q_46 Q_47 Q_48 Q_49
+  Q_50 Q_51 Q_52 Q_53 Q_54 Q_55 Q_56 Q_57 Q_58 Q_59 Q_60 Q_61 Q_62 Q_63
+  STUBDRA_0 STUBDRA_1 STUBDRA__0 STUBDRA__1 STUBDRB_0 STUBDRB_1 STUBDRB__0
+  STUBDRB__1 STUBDWA_0 STUBDWA_1 STUBDWA__0 STUBDWA__1 STUBDWB_0 STUBDWB_1
+  STUBDWB__0 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2WING_32_LEFT: 78017 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA__0 BLA__1 BLA__2 BLA__3
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB__0 BLB__1 BLB__2 BLB__3 D_0 D_1 GTPA_0 GTPA_1
+  GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_0 Q_1 STUBDRA_0_274 STUBDRA_1
+  STUBDRA__0_272 STUBDRA__1 STUBDRB_0_278 STUBDRB_1 STUBDRB__0_276 STUBDRB__1
+  STUBDWA_0_280 STUBDWA_1 STUBDWA__0_282 STUBDWA__1 STUBDWB_0_284 STUBDWB_1
+  STUBDWB__0_286 STUBDWB__1 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI10_0 A0A A0A_ A0B A0B_ BLA_40 BLA_41 BLA_42 BLA_43 BLA__40 BLA__41 BLA__42
+  BLA__43 BLB_40 BLB_41 BLB_42 BLB_43 BLB__40 BLB__41 BLB__42 BLB__43 D_20
+  D_21 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_20 Q_21
+  STUBDRA_0_82 STUBDRA_1_98 STUBDRA__0_80 STUBDRA__1_96 STUBDRB_0_86
+  STUBDRB_1_102 STUBDRB__0_84 STUBDRB__1_100 STUBDWA_0_88 STUBDWA_1_104
+  STUBDWA__0_90 STUBDWA__1_106 STUBDWB_0_92 STUBDWB_1_108 STUBDWB__0_94
+  STUBDWB__1_110 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI11_0 A0A A0A_ A0B A0B_ BLA_47 BLA_46 BLA_45 BLA_44 BLA__47 BLA__46 BLA__45
+  BLA__44 BLB_47 BLB_46 BLB_45 BLB_44 BLB__47 BLB__46 BLB__45 BLB__44 D_23
+  D_22 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_23 Q_22
+  STUBDRA_0_82 STUBDRA_1_114 STUBDRA__0_80 STUBDRA__1_112 STUBDRB_0_86
+  STUBDRB_1_118 STUBDRB__0_84 STUBDRB__1_116 STUBDWA_0_88 STUBDWA_1_120
+  STUBDWA__0_90 STUBDWA__1_122 STUBDWB_0_92 STUBDWB_1_124 STUBDWB__0_94
+  STUBDWB__1_126 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI12_0 A0A A0A_ A0B A0B_ BLA_48 BLA_49 BLA_50 BLA_51 BLA__48 BLA__49 BLA__50
+  BLA__51 BLB_48 BLB_49 BLB_50 BLB_51 BLB__48 BLB__49 BLB__50 BLB__51 D_24
+  D_25 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_24 Q_25
+  STUBDRA_0_146 STUBDRA_1_114 STUBDRA__0_144 STUBDRA__1_112 STUBDRB_0_150
+  STUBDRB_1_118 STUBDRB__0_148 STUBDRB__1_116 STUBDWA_0_152 STUBDWA_1_120
+  STUBDWA__0_154 STUBDWA__1_122 STUBDWB_0_156 STUBDWB_1_124 STUBDWB__0_158
+  STUBDWB__1_126 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI13_0 A0A A0A_ A0B A0B_ BLA_55 BLA_54 BLA_53 BLA_52 BLA__55 BLA__54 BLA__53
+  BLA__52 BLB_55 BLB_54 BLB_53 BLB_52 BLB__55 BLB__54 BLB__53 BLB__52 D_27
+  D_26 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_27 Q_26
+  STUBDRA_0_146 STUBDRA_1_162 STUBDRA__0_144 STUBDRA__1_160 STUBDRB_0_150
+  STUBDRB_1_166 STUBDRB__0_148 STUBDRB__1_164 STUBDWA_0_152 STUBDWA_1_168
+  STUBDWA__0_154 STUBDWA__1_170 STUBDWB_0_156 STUBDWB_1_172 STUBDWB__0_158
+  STUBDWB__1_174 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI14_0 A0A A0A_ A0B A0B_ BLA_56 BLA_57 BLA_58 BLA_59 BLA__56 BLA__57 BLA__58
+  BLA__59 BLB_56 BLB_57 BLB_58 BLB_59 BLB__56 BLB__57 BLB__58 BLB__59 D_28
+  D_29 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_28 Q_29
+  STUBDRA_0_178 STUBDRA_1_162 STUBDRA__0_176 STUBDRA__1_160 STUBDRB_0_182
+  STUBDRB_1_166 STUBDRB__0_180 STUBDRB__1_164 STUBDWA_0_184 STUBDWA_1_168
+  STUBDWA__0_186 STUBDWA__1_170 STUBDWB_0_188 STUBDWB_1_172 STUBDWB__0_190
+  STUBDWB__1_174 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI15_0 A0A A0A_ A0B A0B_ BLA_63 BLA_62 BLA_61 BLA_60 BLA__63 BLA__62 BLA__61
+  BLA__60 BLB_63 BLB_62 BLB_61 BLB_60 BLB__63 BLB__62 BLB__61 BLB__60 D_31
+  D_30 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_31 Q_30
+  STUBDRA_0_178 STUBDRA_1_194 STUBDRA__0_176 STUBDRA__1_192 STUBDRB_0_182
+  STUBDRB_1_198 STUBDRB__0_180 STUBDRB__1_196 STUBDWA_0_184 STUBDWA_1_200
+  STUBDWA__0_186 STUBDWA__1_202 STUBDWB_0_188 STUBDWB_1_204 STUBDWB__0_190
+  STUBDWB__1_206 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI16_0 A0A A0A_ A0B A0B_ BLA_64 BLA_65 BLA_66 BLA_67 BLA__64 BLA__65 BLA__66
+  BLA__67 BLB_64 BLB_65 BLB_66 BLB_67 BLB__64 BLB__65 BLB__66 BLB__67 D_32
+  D_33 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_32 Q_33
+  STUBDRA_0_210 STUBDRA_1_194 STUBDRA__0_208 STUBDRA__1_192 STUBDRB_0_214
+  STUBDRB_1_198 STUBDRB__0_212 STUBDRB__1_196 STUBDWA_0_216 STUBDWA_1_200
+  STUBDWA__0_218 STUBDWA__1_202 STUBDWB_0_220 STUBDWB_1_204 STUBDWB__0_222
+  STUBDWB__1_206 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI17_0 A0A A0A_ A0B A0B_ BLA_71 BLA_70 BLA_69 BLA_68 BLA__71 BLA__70 BLA__69
+  BLA__68 BLB_71 BLB_70 BLB_69 BLB_68 BLB__71 BLB__70 BLB__69 BLB__68 D_35
+  D_34 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_35 Q_34
+  STUBDRA_0_210 STUBDRA_1_226 STUBDRA__0_208 STUBDRA__1_224 STUBDRB_0_214
+  STUBDRB_1_230 STUBDRB__0_212 STUBDRB__1_228 STUBDWA_0_216 STUBDWA_1_232
+  STUBDWA__0_218 STUBDWA__1_234 STUBDWB_0_220 STUBDWB_1_236 STUBDWB__0_222
+  STUBDWB__1_238 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI18_0 A0A A0A_ A0B A0B_ BLA_72 BLA_73 BLA_74 BLA_75 BLA__72 BLA__73 BLA__74
+  BLA__75 BLB_72 BLB_73 BLB_74 BLB_75 BLB__72 BLB__73 BLB__74 BLB__75 D_36
+  D_37 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_36 Q_37
+  STUBDRA_0_242 STUBDRA_1_226 STUBDRA__0_240 STUBDRA__1_224 STUBDRB_0_246
+  STUBDRB_1_230 STUBDRB__0_244 STUBDRB__1_228 STUBDWA_0_248 STUBDWA_1_232
+  STUBDWA__0_250 STUBDWA__1_234 STUBDWB_0_252 STUBDWB_1_236 STUBDWB__0_254
+  STUBDWB__1_238 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI19_0 A0A A0A_ A0B A0B_ BLA_79 BLA_78 BLA_77 BLA_76 BLA__79 BLA__78 BLA__77
+  BLA__76 BLB_79 BLB_78 BLB_77 BLB_76 BLB__79 BLB__78 BLB__77 BLB__76 D_39
+  D_38 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_39 Q_38
+  STUBDRA_0_242 STUBDRA_1_258 STUBDRA__0_240 STUBDRA__1_256 STUBDRB_0_246
+  STUBDRB_1_262 STUBDRB__0_244 STUBDRB__1_260 STUBDWA_0_248 STUBDWA_1_264
+  STUBDWA__0_250 STUBDWA__1_266 STUBDWB_0_252 STUBDWB_1_268 STUBDWB__0_254
+  STUBDWB__1_270 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI1_0 A0A A0A_ A0B A0B_ BLA_7 BLA_6 BLA_5 BLA_4 BLA__7 BLA__6 BLA__5 BLA__4
+  BLB_7 BLB_6 BLB_5 BLB_4 BLB__7 BLB__6 BLB__5 BLB__4 D_3 D_2 GTPA_0 GTPA_1
+  GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_3 Q_2 STUBDRA_0_274 STUBDRA_1_290
+  STUBDRA__0_272 STUBDRA__1_288 STUBDRB_0_278 STUBDRB_1_294 STUBDRB__0_276
+  STUBDRB__1_292 STUBDWA_0_280 STUBDWA_1_296 STUBDWA__0_282 STUBDWA__1_298
+  STUBDWB_0_284 STUBDWB_1_300 STUBDWB__0_286 STUBDWB__1_302 STUBWEA STUBWEB
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31
+  WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41
+  WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51
+  WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61
+  WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39
+  WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49
+  WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59
+  WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1
+  YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD
+  VSS Mem_cnnin2MCOL_MEL4
XI20_0 A0A A0A_ A0B A0B_ BLA_80 BLA_81 BLA_82 BLA_83 BLA__80 BLA__81 BLA__82
+  BLA__83 BLB_80 BLB_81 BLB_82 BLB_83 BLB__80 BLB__81 BLB__82 BLB__83 D_40
+  D_41 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_40 Q_41
+  STUBDRA_0_418 STUBDRA_1_258 STUBDRA__0_416 STUBDRA__1_256 STUBDRB_0_422
+  STUBDRB_1_262 STUBDRB__0_420 STUBDRB__1_260 STUBDWA_0_424 STUBDWA_1_264
+  STUBDWA__0_426 STUBDWA__1_266 STUBDWB_0_428 STUBDWB_1_268 STUBDWB__0_430
+  STUBDWB__1_270 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI21_0 A0A A0A_ A0B A0B_ BLA_87 BLA_86 BLA_85 BLA_84 BLA__87 BLA__86 BLA__85
+  BLA__84 BLB_87 BLB_86 BLB_85 BLB_84 BLB__87 BLB__86 BLB__85 BLB__84 D_43
+  D_42 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_43 Q_42
+  STUBDRA_0_418 STUBDRA_1_434 STUBDRA__0_416 STUBDRA__1_432 STUBDRB_0_422
+  STUBDRB_1_438 STUBDRB__0_420 STUBDRB__1_436 STUBDWA_0_424 STUBDWA_1_440
+  STUBDWA__0_426 STUBDWA__1_442 STUBDWB_0_428 STUBDWB_1_444 STUBDWB__0_430
+  STUBDWB__1_446 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI22_0 A0A A0A_ A0B A0B_ BLA_88 BLA_89 BLA_90 BLA_91 BLA__88 BLA__89 BLA__90
+  BLA__91 BLB_88 BLB_89 BLB_90 BLB_91 BLB__88 BLB__89 BLB__90 BLB__91 D_44
+  D_45 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_44 Q_45
+  STUBDRA_0_450 STUBDRA_1_434 STUBDRA__0_448 STUBDRA__1_432 STUBDRB_0_454
+  STUBDRB_1_438 STUBDRB__0_452 STUBDRB__1_436 STUBDWA_0_456 STUBDWA_1_440
+  STUBDWA__0_458 STUBDWA__1_442 STUBDWB_0_460 STUBDWB_1_444 STUBDWB__0_462
+  STUBDWB__1_446 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI23_0 A0A A0A_ A0B A0B_ BLA_95 BLA_94 BLA_93 BLA_92 BLA__95 BLA__94 BLA__93
+  BLA__92 BLB_95 BLB_94 BLB_93 BLB_92 BLB__95 BLB__94 BLB__93 BLB__92 D_47
+  D_46 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_47 Q_46
+  STUBDRA_0_450 STUBDRA_1_466 STUBDRA__0_448 STUBDRA__1_464 STUBDRB_0_454
+  STUBDRB_1_470 STUBDRB__0_452 STUBDRB__1_468 STUBDWA_0_456 STUBDWA_1_472
+  STUBDWA__0_458 STUBDWA__1_474 STUBDWB_0_460 STUBDWB_1_476 STUBDWB__0_462
+  STUBDWB__1_478 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI24_0 A0A A0A_ A0B A0B_ BLA_96 BLA_97 BLA_98 BLA_99 BLA__96 BLA__97 BLA__98
+  BLA__99 BLB_96 BLB_97 BLB_98 BLB_99 BLB__96 BLB__97 BLB__98 BLB__99 D_48
+  D_49 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_48 Q_49
+  STUBDRA_0_482 STUBDRA_1_466 STUBDRA__0_480 STUBDRA__1_464 STUBDRB_0_486
+  STUBDRB_1_470 STUBDRB__0_484 STUBDRB__1_468 STUBDWA_0_488 STUBDWA_1_472
+  STUBDWA__0_490 STUBDWA__1_474 STUBDWB_0_492 STUBDWB_1_476 STUBDWB__0_494
+  STUBDWB__1_478 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI25_0 A0A A0A_ A0B A0B_ BLA_103 BLA_102 BLA_101 BLA_100 BLA__103 BLA__102
+  BLA__101 BLA__100 BLB_103 BLB_102 BLB_101 BLB_100 BLB__103 BLB__102
+  BLB__101 BLB__100 D_51 D_50 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_51 Q_50 STUBDRA_0_482 STUBDRA_1_18 STUBDRA__0_480 STUBDRA__1_16
+  STUBDRB_0_486 STUBDRB_1_22 STUBDRB__0_484 STUBDRB__1_20 STUBDWA_0_488
+  STUBDWA_1_24 STUBDWA__0_490 STUBDWA__1_26 STUBDWB_0_492 STUBDWB_1_28
+  STUBDWB__0_494 STUBDWB__1_30 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI26_0 A0A A0A_ A0B A0B_ BLA_104 BLA_105 BLA_106 BLA_107 BLA__104 BLA__105
+  BLA__106 BLA__107 BLB_104 BLB_105 BLB_106 BLB_107 BLB__104 BLB__105
+  BLB__106 BLB__107 D_52 D_53 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_52 Q_53 STUBDRA_0_2 STUBDRA_1_18 STUBDRA__0_0 STUBDRA__1_16
+  STUBDRB_0_6 STUBDRB_1_22 STUBDRB__0_4 STUBDRB__1_20 STUBDWA_0_8
+  STUBDWA_1_24 STUBDWA__0_10 STUBDWA__1_26 STUBDWB_0_12 STUBDWB_1_28
+  STUBDWB__0_14 STUBDWB__1_30 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI27_0 A0A A0A_ A0B A0B_ BLA_111 BLA_110 BLA_109 BLA_108 BLA__111 BLA__110
+  BLA__109 BLA__108 BLB_111 BLB_110 BLB_109 BLB_108 BLB__111 BLB__110
+  BLB__109 BLB__108 D_55 D_54 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_55 Q_54 STUBDRA_0_2 STUBDRA_1_34 STUBDRA__0_0 STUBDRA__1_32
+  STUBDRB_0_6 STUBDRB_1_38 STUBDRB__0_4 STUBDRB__1_36 STUBDWA_0_8
+  STUBDWA_1_40 STUBDWA__0_10 STUBDWA__1_42 STUBDWB_0_12 STUBDWB_1_44
+  STUBDWB__0_14 STUBDWB__1_46 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI28_0 A0A A0A_ A0B A0B_ BLA_112 BLA_113 BLA_114 BLA_115 BLA__112 BLA__113
+  BLA__114 BLA__115 BLB_112 BLB_113 BLB_114 BLB_115 BLB__112 BLB__113
+  BLB__114 BLB__115 D_56 D_57 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_56 Q_57 STUBDRA_0_50 STUBDRA_1_34 STUBDRA__0_48 STUBDRA__1_32
+  STUBDRB_0_54 STUBDRB_1_38 STUBDRB__0_52 STUBDRB__1_36 STUBDWA_0_56
+  STUBDWA_1_40 STUBDWA__0_58 STUBDWA__1_42 STUBDWB_0_60 STUBDWB_1_44
+  STUBDWB__0_62 STUBDWB__1_46 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI29_0 A0A A0A_ A0B A0B_ BLA_119 BLA_118 BLA_117 BLA_116 BLA__119 BLA__118
+  BLA__117 BLA__116 BLB_119 BLB_118 BLB_117 BLB_116 BLB__119 BLB__118
+  BLB__117 BLB__116 D_59 D_58 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_59 Q_58 STUBDRA_0_50 STUBDRA_1_66 STUBDRA__0_48 STUBDRA__1_64
+  STUBDRB_0_54 STUBDRB_1_70 STUBDRB__0_52 STUBDRB__1_68 STUBDWA_0_56
+  STUBDWA_1_72 STUBDWA__0_58 STUBDWA__1_74 STUBDWB_0_60 STUBDWB_1_76
+  STUBDWB__0_62 STUBDWB__1_78 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI2_0 A0A A0A_ A0B A0B_ BLA_8 BLA_9 BLA_10 BLA_11 BLA__8 BLA__9 BLA__10
+  BLA__11 BLB_8 BLB_9 BLB_10 BLB_11 BLB__8 BLB__9 BLB__10 BLB__11 D_4 D_5
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_4 Q_5 STUBDRA_0_306
+  STUBDRA_1_290 STUBDRA__0_304 STUBDRA__1_288 STUBDRB_0_310 STUBDRB_1_294
+  STUBDRB__0_308 STUBDRB__1_292 STUBDWA_0_312 STUBDWA_1_296 STUBDWA__0_314
+  STUBDWA__1_298 STUBDWB_0_316 STUBDWB_1_300 STUBDWB__0_318 STUBDWB__1_302
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI30_0 A0A A0A_ A0B A0B_ BLA_120 BLA_121 BLA_122 BLA_123 BLA__120 BLA__121
+  BLA__122 BLA__123 BLB_120 BLB_121 BLB_122 BLB_123 BLB__120 BLB__121
+  BLB__122 BLB__123 D_60 D_61 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_60 Q_61 STUBDRA_0_130 STUBDRA_1_66 STUBDRA__0_128 STUBDRA__1_64
+  STUBDRB_0_134 STUBDRB_1_70 STUBDRB__0_132 STUBDRB__1_68 STUBDWA_0_136
+  STUBDWA_1_72 STUBDWA__0_138 STUBDWA__1_74 STUBDWB_0_140 STUBDWB_1_76
+  STUBDWB__0_142 STUBDWB__1_78 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35
+  WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45
+  WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55
+  WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI31_0 A0A A0A_ A0B A0B_ BLA_127 BLA_126 BLA_125 BLA_124 BLA__127 BLA__126
+  BLA__125 BLA__124 BLB_127 BLB_126 BLB_125 BLB_124 BLB__127 BLB__126
+  BLB__125 BLB__124 D_63 D_62 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_
+  OEB_ Q_63 Q_62 STUBDRA_0_130 STUBDRA_0 STUBDRA__0_128 STUBDRA__0
+  STUBDRB_0_134 STUBDRB_0 STUBDRB__0_132 STUBDRB__0 STUBDWA_0_136 STUBDWA_0
+  STUBDWA__0_138 STUBDWA__0 STUBDWB_0_140 STUBDWB_0 STUBDWB__0_142 STUBDWB__0
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_LEL4
XI3_0 A0A A0A_ A0B A0B_ BLA_15 BLA_14 BLA_13 BLA_12 BLA__15 BLA__14 BLA__13
+  BLA__12 BLB_15 BLB_14 BLB_13 BLB_12 BLB__15 BLB__14 BLB__13 BLB__12 D_7 D_6
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_7 Q_6 STUBDRA_0_306
+  STUBDRA_1_322 STUBDRA__0_304 STUBDRA__1_320 STUBDRB_0_310 STUBDRB_1_326
+  STUBDRB__0_308 STUBDRB__1_324 STUBDWA_0_312 STUBDWA_1_328 STUBDWA__0_314
+  STUBDWA__1_330 STUBDWB_0_316 STUBDWB_1_332 STUBDWB__0_318 STUBDWB__1_334
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI4_0 A0A A0A_ A0B A0B_ BLA_16 BLA_17 BLA_18 BLA_19 BLA__16 BLA__17 BLA__18
+  BLA__19 BLB_16 BLB_17 BLB_18 BLB_19 BLB__16 BLB__17 BLB__18 BLB__19 D_8 D_9
+  GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_8 Q_9 STUBDRA_0_338
+  STUBDRA_1_322 STUBDRA__0_336 STUBDRA__1_320 STUBDRB_0_342 STUBDRB_1_326
+  STUBDRB__0_340 STUBDRB__1_324 STUBDWA_0_344 STUBDWA_1_328 STUBDWA__0_346
+  STUBDWA__1_330 STUBDWB_0_348 STUBDWB_1_332 STUBDWB__0_350 STUBDWB__1_334
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI5_0 A0A A0A_ A0B A0B_ BLA_23 BLA_22 BLA_21 BLA_20 BLA__23 BLA__22 BLA__21
+  BLA__20 BLB_23 BLB_22 BLB_21 BLB_20 BLB__23 BLB__22 BLB__21 BLB__20 D_11
+  D_10 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_11 Q_10
+  STUBDRA_0_338 STUBDRA_1_354 STUBDRA__0_336 STUBDRA__1_352 STUBDRB_0_342
+  STUBDRB_1_358 STUBDRB__0_340 STUBDRB__1_356 STUBDWA_0_344 STUBDWA_1_360
+  STUBDWA__0_346 STUBDWA__1_362 STUBDWB_0_348 STUBDWB_1_364 STUBDWB__0_350
+  STUBDWB__1_366 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI6_0 A0A A0A_ A0B A0B_ BLA_24 BLA_25 BLA_26 BLA_27 BLA__24 BLA__25 BLA__26
+  BLA__27 BLB_24 BLB_25 BLB_26 BLB_27 BLB__24 BLB__25 BLB__26 BLB__27 D_12
+  D_13 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_12 Q_13
+  STUBDRA_0_370 STUBDRA_1_354 STUBDRA__0_368 STUBDRA__1_352 STUBDRB_0_374
+  STUBDRB_1_358 STUBDRB__0_372 STUBDRB__1_356 STUBDWA_0_376 STUBDWA_1_360
+  STUBDWA__0_378 STUBDWA__1_362 STUBDWB_0_380 STUBDWB_1_364 STUBDWB__0_382
+  STUBDWB__1_366 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI7_0 A0A A0A_ A0B A0B_ BLA_31 BLA_30 BLA_29 BLA_28 BLA__31 BLA__30 BLA__29
+  BLA__28 BLB_31 BLB_30 BLB_29 BLB_28 BLB__31 BLB__30 BLB__29 BLB__28 D_15
+  D_14 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_15 Q_14
+  STUBDRA_0_370 STUBDRA_1_386 STUBDRA__0_368 STUBDRA__1_384 STUBDRB_0_374
+  STUBDRB_1_390 STUBDRB__0_372 STUBDRB__1_388 STUBDWA_0_376 STUBDWA_1_392
+  STUBDWA__0_378 STUBDWA__1_394 STUBDWB_0_380 STUBDWB_1_396 STUBDWB__0_382
+  STUBDWB__1_398 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
XI8_0 A0A A0A_ A0B A0B_ BLA_32 BLA_33 BLA_34 BLA_35 BLA__32 BLA__33 BLA__34
+  BLA__35 BLB_32 BLB_33 BLB_34 BLB_35 BLB__32 BLB__33 BLB__34 BLB__35 D_16
+  D_17 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_16 Q_17
+  STUBDRA_0_402 STUBDRA_1_386 STUBDRA__0_400 STUBDRA__1_384 STUBDRB_0_406
+  STUBDRB_1_390 STUBDRB__0_404 STUBDRB__1_388 STUBDWA_0_408 STUBDWA_1_392
+  STUBDWA__0_410 STUBDWA__1_394 STUBDWB_0_412 STUBDWB_1_396 STUBDWB__0_414
+  STUBDWB__1_398 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MOL4
XI9_0 A0A A0A_ A0B A0B_ BLA_39 BLA_38 BLA_37 BLA_36 BLA__39 BLA__38 BLA__37
+  BLA__36 BLB_39 BLB_38 BLB_37 BLB_36 BLB__39 BLB__38 BLB__37 BLB__36 D_19
+  D_18 GTPA_0 GTPA_1 GTPA_2 GTPB_0 GTPB_1 GTPB_2 OEA_ OEB_ Q_19 Q_18
+  STUBDRA_0_402 STUBDRA_1_98 STUBDRA__0_400 STUBDRA__1_96 STUBDRB_0_406
+  STUBDRB_1_102 STUBDRB__0_404 STUBDRB__1_100 STUBDWA_0_408 STUBDWA_1_104
+  STUBDWA__0_410 STUBDWA__1_106 STUBDWB_0_412 STUBDWB_1_108 STUBDWB__0_414
+  STUBDWB__1_110 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2MCOL_MEL4
.ENDS Mem_cnnin2WING_32_LEFT
****
.SUBCKT Mem_cnnin2HBF4 CEN CLK GSRCN GTP GTPA GTPB GTPN MBL RST STOV STUBBWA
+  STUBBWB TMS WEI WEIA WEIB WEN VDD VSS
** Mem_cnnin2HBF4: 76 flat devices **
d72 VSS WEN tdndsx AREA=0.1024P PERIM=1.28U
d73 VSS CEN tdndsx AREA=0.1024P PERIM=1.28U
d74 VSS STOV tdndsx AREA=0.1024P PERIM=1.28U
d75 VSS CLK tdndsx AREA=0.1024P PERIM=1.28U
d76 VSS TMS tdndsx AREA=0.1024P PERIM=1.28U
m1 WEI N35 VDD VDD lppfet L=0.12U W=7.67U
m10 BF-CLKN CLK VSS VSS lpnfet L=0.26U W=0.38U
m11 N79 GTP VSS VSS lpnfet L=0.12U W=0.91U
m12 BF-RSRCN BF-CKSTOV N79 VSS lpnfet L=0.12U W=0.91U
m13 BF-RSRCN GTP VDD VDD lppfet L=0.12U W=1.43U
m14 N78 GTP VSS VSS lpnfet L=0.12U W=0.91U
m15 BF-RSRCN BF-CKSTOV VDD VDD lppfet L=0.12U W=1.43U
m16 BF-RSRCN BF-CKSTOV N78 VSS lpnfet L=0.12U W=0.91U
m17 BF-RSTSRC BF-RSRCN VDD VDD lppfet L=0.12U W=4.32U
m18 BF-RSTSRC BF-RSRCN VSS VSS lpnfet L=0.12U W=2.77U
m19 BF-CKSTOV STOV VDD VDD lppfet L=0.12U W=0.58U
m2 WEI N35 VSS VSS lpnfet L=0.12U W=5.39U
m20 N80 STOV VSS VSS lpnfet L=0.12U W=0.74U
m21 BF-CKSTOV CLK VDD VDD lppfet L=0.12U W=0.58U
m22 BF-CKSTOV CLK N80 VSS lpnfet L=0.12U W=0.74U
m23 GTPN BF-GTPI N50 VSS lpnfet L=0.12U W=0.16U
m24 N29 N29 VDD VDD lppfet L=0.12U W=0.16U
m25 GTPN BF-GTPI VDD VDD lppfet L=0.12U W=0.16U
m26 N29 VDD VDD VDD lppfet L=0.12U W=0.16U
m27 BF-GTPI GTPN VDD VDD lppfet L=0.12U W=0.3U
m28 BF-GTPI GTPN VSS VSS lpnfet L=0.12U W=0.16U
m29 N50 N29 VSS VSS lpnfet L=0.12U W=0.16U
m3 BF-CENMML BF-CLKN N77 VDD lppfet L=0.12U W=0.16U
m30 N82 BF-CLKN VSS VSS lpnfet L=0.12U W=1.78U
m31 GSRCN BF-CEL N82 VSS lpnfet L=0.12U W=1.78U
m32 GSRCN BF-CLKN VDD VDD lppfet L=0.12U W=2.22U
m33 N81 BF-CLKN VSS VSS lpnfet L=0.12U W=1.78U
m34 GSRCN BF-CEL VDD VDD lppfet L=0.12U W=2.22U
m35 GSRCN BF-CEL N81 VSS lpnfet L=0.12U W=1.78U
m36 N59 BF-CLKN VSS VSS lpnfet L=0.12U W=0.34U
m37 N61 CLK VDD VDD lppfet L=0.12U W=0.63U
m38 BF-CENMML N63 N64 VDD lppfet L=0.12U W=0.63U
m39 BF-CENMML N63 N59 VSS lpnfet L=0.12U W=0.34U
m4 N77 BF-CEL VDD VDD lppfet L=0.12U W=0.16U
m40 N64 TMS N61 VDD lppfet L=0.12U W=0.63U
m41 BF-CENMML TMS N59 VSS lpnfet L=0.12U W=0.34U
m42 RST BF-MBLN VDD VDD lppfet L=0.12U W=2.25U
m43 RST BF-RSTSRC VDD VDD lppfet L=0.12U W=7.66U
m44 BF-MBLN MBL VDD VDD lppfet L=0.12U W=3.28U
m45 BF-MBLN MBL VSS VSS lpnfet L=0.12U W=1.5U
m46 N69 WEN VDD VDD lppfet L=0.12U W=0.79U
m47 N69 WEN VSS VSS lpnfet L=0.12U W=0.53U
m48 N63 CEN VDD VDD lppfet L=0.12U W=0.7U
m49 N63 CEN VSS VSS lpnfet L=0.12U W=0.47U
m5 BF-CENMML CLK N76 VSS lpnfet L=0.12U W=0.16U
m50 RST BF-MBLN N92 VSS lpnfet L=0.12U W=1.28U
m51 N92 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m52 RST BF-MBLN N91 VSS lpnfet L=0.12U W=1.28U
m53 N91 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m54 RST BF-MBLN N90 VSS lpnfet L=0.12U W=1.28U
m55 N90 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m56 RST BF-MBLN N89 VSS lpnfet L=0.12U W=1.28U
m57 N89 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m58 RST BF-MBLN N88 VSS lpnfet L=0.12U W=1.28U
m59 N88 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m6 N76 BF-CEL VSS VSS lpnfet L=0.12U W=0.16U
m60 RST BF-MBLN N87 VSS lpnfet L=0.12U W=1.28U
m61 N87 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m62 RST BF-MBLN N86 VSS lpnfet L=0.12U W=1.28U
m63 N86 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m64 RST BF-MBLN N85 VSS lpnfet L=0.12U W=1.28U
m65 N85 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m66 RST BF-MBLN N84 VSS lpnfet L=0.12U W=1.28U
m67 N84 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m68 RST BF-MBLN N83 VSS lpnfet L=0.12U W=1.28U
m69 N83 BF-RSTSRC VSS VSS lpnfet L=0.12U W=1.66U
m7 BF-CEL BF-CENMML VDD VDD lppfet L=0.12U W=0.91U
m70 N35 N69 VDD VDD lppfet L=0.12U W=2.24U
m71 N35 N69 VSS VSS lpnfet L=0.12U W=1.44U
m8 BF-CEL BF-CENMML VSS VSS lpnfet L=0.12U W=0.65U
m9 BF-CLKN CLK VDD VDD lppfet L=0.12U W=1.05U
.ENDS Mem_cnnin2HBF4
****
.SUBCKT Mem_cnnin2HBFX_B CEN CLK GSRCN GTPA GTPB GTPN MBL RST STUBBWA STUBBWB
+  WEIA WEIB WEN VDD VSS
** Mem_cnnin2HBFX_B: 76 flat devices **
XI0_0 CEN CLK GSRCN GTPB GTPA GTPB GTPN MBL RST VSS STUBBWA STUBBWB VSS WEIB
+  WEIA WEIB WEN VDD VSS Mem_cnnin2HBF4
.ENDS Mem_cnnin2HBFX_B
****
.SUBCKT Mem_cnnin2FLCIOX_B A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBLA
+  MBLA_ MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2FLCIOX_B: 22 flat devices **
XI0_0 A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBLA MBLA_ MBL MBLB_
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2FLCIO
.ENDS Mem_cnnin2FLCIOX_B
****
.SUBCKT Mem_cnnin2HCKA A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTPN RST YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS lpnfet L=0.12U W=18.84U
m2 GTPN CLK CK-GTPFEED VSS lpnfet L=0.12U W=6.27U
m3 GTPN RST VDD VDD lppfet L=0.12U W=8.92U
m4 AGTP GTPN VDD VDD lppfet L=0.12U W=27.52U
m5 AGTP GTPN VSS VSS lpnfet L=0.12U W=12.44U
m6 CK-GTPNSRC GSRCN VDD VDD lppfet L=0.12U W=2.12U
m7 CK-GTPNSRC GSRCN VSS VSS lpnfet L=0.12U W=1.64U
m8 CK-GTPFEED CLK CK-SRCFEED VSS lpnfet L=0.12U W=6.27U
m9 CK-GTPFEED GTPN VDD VSS lpnfet L=0.12U W=1.58U
.ENDS Mem_cnnin2HCKA
****
.SUBCKT Mem_cnnin2CK A0A A0A_ A0B A0B_ CLK GSRCN GTP GTPN RST YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS lpnfet L=0.12U W=18.84U
m2 GTPN CLK GTPFEED VSS lpnfet L=0.12U W=6.27U
m3 GTPN RST VDD VDD lppfet L=0.12U W=8.92U
m4 GTP GTPN VDD VDD lppfet L=0.12U W=27.52U
m5 GTP GTPN VSS VSS lpnfet L=0.12U W=12.44U
m6 GTPNSRC GSRCN VDD VDD lppfet L=0.12U W=2.12U
m7 GTPNSRC GSRCN VSS VSS lpnfet L=0.12U W=1.64U
m8 GTPFEED CLK SRCFEED VSS lpnfet L=0.12U W=6.27U
m9 GTPFEED GTPN VDD VSS lpnfet L=0.12U W=1.58U
.ENDS Mem_cnnin2CK
****
.SUBCKT Mem_cnnin2CK1 A0A A0A_ A0B A0B_ CLK GSRCN GTP GTPN RST YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2CK1: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS lpnfet L=0.12U W=18.84U
m2 GTPN CLK GTPFEED VSS lpnfet L=0.12U W=6.27U
m3 GTPN RST VDD VDD lppfet L=0.12U W=8.92U
m4 GTP GTPN VDD VDD lppfet L=0.12U W=27.52U
m5 GTP GTPN VSS VSS lpnfet L=0.12U W=12.44U
m6 GTPNSRC GSRCN VDD VDD lppfet L=0.12U W=2.12U
m7 GTPNSRC GSRCN VSS VSS lpnfet L=0.12U W=1.64U
m8 GTPFEED CLK SRCFEED VSS lpnfet L=0.12U W=6.27U
m9 GTPFEED GTPN VDD VSS lpnfet L=0.12U W=1.58U
.ENDS Mem_cnnin2CK1
****
.SUBCKT Mem_cnnin2CLK_DRVS A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTPN GTP_0 GTP_1
+  GTP_2 GTP_3 RST YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2CLK_DRVS: 45 flat devices **
XI0_0 A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HCKA
XI1_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_0 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2CK
XI2_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_1 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2CK
XI3_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_2 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2CK
XI4_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_3 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2CK1
.ENDS Mem_cnnin2CLK_DRVS
****
.SUBCKT Mem_cnnin2HYP12XL A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YP0_0 YP0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS
** Mem_cnnin2HYP12XL: 95 flat devices **
d10 VSS BWENA tdndsx AREA=0.1024P PERIM=1.28U
d11 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
d7 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS WEIA tdndsx AREA=0.1024P PERIM=1.28U
d9 VSS WEIB tdndsx AREA=0.1024P PERIM=1.28U
m1 N23 N29 VDD VDD lppfet L=0.12U W=2.3U
m12 AP01-APN1 N49 AP01-AIND1 VSS lpnfet L=0.12U W=3.32U
m13 AP01-APN1 AGTPT AP01-AIND1 VDD lppfet L=0.12U W=4.15U
m14 N49 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m15 N49 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m16 AP01-AIN21 N23 VDD VDD lppfet L=0.12U W=2.03U
m17 AP01-AIN21 N23 VSS VSS lpnfet L=0.12U W=1.34U
m18 N43 VSS VDD VDD lppfet L=0.12U W=2.03U
m19 N43 VSS VSS VSS lpnfet L=0.12U W=1.34U
m2 N23 N29 VSS VSS lpnfet L=0.12U W=1.54U
m20 N44 VSS VDD VDD lppfet L=0.12U W=2.03U
m21 N44 VSS VSS VSS lpnfet L=0.12U W=1.34U
m22 N78 N44 VSS VSS lpnfet L=0.12U W=3.32U
m23 N77 N43 N78 VSS lpnfet L=0.12U W=3.32U
m24 AP01-AIND1 AP01-AIN21 N77 VSS lpnfet L=0.12U W=3.32U
m25 AP01-AIND1 N44 VDD VDD lppfet L=0.12U W=4.16U
m26 N76 N44 VSS VSS lpnfet L=0.12U W=3.32U
m27 AP01-AIND1 N43 VDD VDD lppfet L=0.12U W=4.16U
m28 N75 N43 N76 VSS lpnfet L=0.12U W=3.32U
m29 AP01-AIND1 AP01-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m3 N22 A0 VDD VDD lppfet L=0.12U W=2.3U
m30 AP01-AIND1 AP01-AIN21 N75 VSS lpnfet L=0.12U W=3.32U
m31 AP01-APN0 N60 AP01-AIND0 VSS lpnfet L=0.12U W=3.32U
m32 AP01-APN0 AGTPB AP01-AIND0 VDD lppfet L=0.12U W=4.15U
m33 N60 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m34 N60 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m35 AP01-AIN20 N22 VDD VDD lppfet L=0.12U W=2.03U
m36 AP01-AIN20 N22 VSS VSS lpnfet L=0.12U W=1.34U
m37 N82 N44 VSS VSS lpnfet L=0.12U W=3.32U
m38 N81 N43 N82 VSS lpnfet L=0.12U W=3.32U
m39 AP01-AIND0 AP01-AIN20 N81 VSS lpnfet L=0.12U W=3.32U
m4 N22 A0 VSS VSS lpnfet L=0.12U W=1.54U
m40 AP01-AIND0 N44 VDD VDD lppfet L=0.12U W=4.16U
m41 N80 N44 VSS VSS lpnfet L=0.12U W=3.32U
m42 AP01-AIND0 N43 VDD VDD lppfet L=0.12U W=4.16U
m43 N79 N43 N80 VSS lpnfet L=0.12U W=3.32U
m44 AP01-AIND0 AP01-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m45 AP01-AIND0 AP01-AIN20 N79 VSS lpnfet L=0.12U W=3.32U
m46 AP01-APN1 YP0_0 VDD VDD lppfet L=0.2U W=0.16U
m47 AP01-APN1 YP0_0 VSS VSS lpnfet L=0.39U W=0.16U
m48 YP0_0 AP01-APN1 VDD VDD lppfet L=0.12U W=13.74U
m49 YP0_0 AP01-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m5 N29 A0 VDD VDD lppfet L=0.12U W=1.84U
m50 AP01-APN0 YP0_1 VDD VDD lppfet L=0.2U W=0.16U
m51 AP01-APN0 YP0_1 VSS VSS lpnfet L=0.39U W=0.16U
m52 YP0_1 AP01-APN0 VDD VDD lppfet L=0.12U W=13.74U
m53 YP0_1 AP01-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m54 AP10-APN1 N91 AP10-AIND1 VSS lpnfet L=0.12U W=3.32U
m55 AP10-APN1 AGTPT AP10-AIND1 VDD lppfet L=0.12U W=4.15U
m56 N91 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m57 N91 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m58 AP10-AIN21 N23 VDD VDD lppfet L=0.12U W=2.03U
m59 AP10-AIN21 N23 VSS VSS lpnfet L=0.12U W=1.34U
m6 N29 A0 VSS VSS lpnfet L=0.12U W=1.24U
m60 N85 VSS VDD VDD lppfet L=0.12U W=2.03U
m61 N85 VSS VSS VSS lpnfet L=0.12U W=1.34U
m62 N86 VSS VDD VDD lppfet L=0.12U W=2.03U
m63 N86 VSS VSS VSS lpnfet L=0.12U W=1.34U
m64 N120 N86 VSS VSS lpnfet L=0.12U W=3.32U
m65 N119 N85 N120 VSS lpnfet L=0.12U W=3.32U
m66 AP10-AIND1 AP10-AIN21 N119 VSS lpnfet L=0.12U W=3.32U
m67 AP10-AIND1 N86 VDD VDD lppfet L=0.12U W=4.16U
m68 N118 N86 VSS VSS lpnfet L=0.12U W=3.32U
m69 AP10-AIND1 N85 VDD VDD lppfet L=0.12U W=4.16U
m70 N117 N85 N118 VSS lpnfet L=0.12U W=3.32U
m71 AP10-AIND1 AP10-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m72 AP10-AIND1 AP10-AIN21 N117 VSS lpnfet L=0.12U W=3.32U
m73 AP10-APN0 N102 AP10-AIND0 VSS lpnfet L=0.12U W=3.32U
m74 AP10-APN0 AGTPB AP10-AIND0 VDD lppfet L=0.12U W=4.15U
m75 N102 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m76 N102 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m77 AP10-AIN20 N22 VDD VDD lppfet L=0.12U W=2.03U
m78 AP10-AIN20 N22 VSS VSS lpnfet L=0.12U W=1.34U
m79 N124 N86 VSS VSS lpnfet L=0.12U W=3.32U
m80 N123 N85 N124 VSS lpnfet L=0.12U W=3.32U
m81 AP10-AIND0 AP10-AIN20 N123 VSS lpnfet L=0.12U W=3.32U
m82 AP10-AIND0 N86 VDD VDD lppfet L=0.12U W=4.16U
m83 N122 N86 VSS VSS lpnfet L=0.12U W=3.32U
m84 AP10-AIND0 N85 VDD VDD lppfet L=0.12U W=4.16U
m85 N121 N85 N122 VSS lpnfet L=0.12U W=3.32U
m86 AP10-AIND0 AP10-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m87 AP10-AIND0 AP10-AIN20 N121 VSS lpnfet L=0.12U W=3.32U
m88 AP10-APN1 YP0_0 VDD VDD lppfet L=0.2U W=0.16U
m89 AP10-APN1 YP0_0 VSS VSS lpnfet L=0.39U W=0.16U
m90 YP0_0 AP10-APN1 VDD VDD lppfet L=0.12U W=13.74U
m91 YP0_0 AP10-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m92 AP10-APN0 YP0_1 VDD VDD lppfet L=0.2U W=0.16U
m93 AP10-APN0 YP0_1 VSS VSS lpnfet L=0.39U W=0.16U
m94 YP0_1 AP10-APN0 VDD VDD lppfet L=0.12U W=13.74U
m95 YP0_1 AP10-APN0 VSS VSS lpnfet L=0.12U W=9.48U
.ENDS Mem_cnnin2HYP12XL
****
.SUBCKT Mem_cnnin2HYP12XLX_B A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS
** Mem_cnnin2HYP12XLX_B: 95 flat devices **
XI0_0 A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPB0_0 YPB0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS Mem_cnnin2HYP12XL
.ENDS Mem_cnnin2HYP12XLX_B
****
.SUBCKT Mem_cnnin2HYP12XR A0 AGTP AY0 AY0A AY0A_ AY0B AY0B_ AY0_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS
** Mem_cnnin2HYP12XR: 95 flat devices **
d10 VSS BWENA tdndsx AREA=0.1024P PERIM=1.28U
d11 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
d7 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS WEIA tdndsx AREA=0.1024P PERIM=1.28U
d9 VSS WEIB tdndsx AREA=0.1024P PERIM=1.28U
m1 N37 N43 VDD VDD lppfet L=0.12U W=2.3U
m12 AP0-APN1 N63 AP0-AIND1 VSS lpnfet L=0.12U W=3.32U
m13 AP0-APN1 AGTP AP0-AIND1 VDD lppfet L=0.12U W=4.15U
m14 N63 AGTP VDD VDD lppfet L=0.12U W=0.58U
m15 N63 AGTP VSS VSS lpnfet L=0.12U W=0.5U
m16 AP0-AIN21 N37 VDD VDD lppfet L=0.12U W=2.03U
m17 AP0-AIN21 N37 VSS VSS lpnfet L=0.12U W=1.34U
m18 N57 VSS VDD VDD lppfet L=0.12U W=2.03U
m19 N57 VSS VSS VSS lpnfet L=0.12U W=1.34U
m2 N37 N43 VSS VSS lpnfet L=0.12U W=1.54U
m20 N58 VSS VDD VDD lppfet L=0.12U W=2.03U
m21 N58 VSS VSS VSS lpnfet L=0.12U W=1.34U
m22 N92 N58 VSS VSS lpnfet L=0.12U W=3.32U
m23 N91 N57 N92 VSS lpnfet L=0.12U W=3.32U
m24 AP0-AIND1 AP0-AIN21 N91 VSS lpnfet L=0.12U W=3.32U
m25 AP0-AIND1 N58 VDD VDD lppfet L=0.12U W=4.16U
m26 N90 N58 VSS VSS lpnfet L=0.12U W=3.32U
m27 AP0-AIND1 N57 VDD VDD lppfet L=0.12U W=4.16U
m28 N89 N57 N90 VSS lpnfet L=0.12U W=3.32U
m29 AP0-AIND1 AP0-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m3 N36 A0 VDD VDD lppfet L=0.12U W=2.3U
m30 AP0-AIND1 AP0-AIN21 N89 VSS lpnfet L=0.12U W=3.32U
m31 AP0-APN0 N74 AP0-AIND0 VSS lpnfet L=0.12U W=3.32U
m32 AP0-APN0 AGTP AP0-AIND0 VDD lppfet L=0.12U W=4.15U
m33 N74 AGTP VDD VDD lppfet L=0.12U W=0.58U
m34 N74 AGTP VSS VSS lpnfet L=0.12U W=0.5U
m35 AP0-AIN20 N36 VDD VDD lppfet L=0.12U W=2.03U
m36 AP0-AIN20 N36 VSS VSS lpnfet L=0.12U W=1.34U
m37 N96 N58 VSS VSS lpnfet L=0.12U W=3.32U
m38 N95 N57 N96 VSS lpnfet L=0.12U W=3.32U
m39 AP0-AIND0 AP0-AIN20 N95 VSS lpnfet L=0.12U W=3.32U
m4 N36 A0 VSS VSS lpnfet L=0.12U W=1.54U
m40 AP0-AIND0 N58 VDD VDD lppfet L=0.12U W=4.16U
m41 N94 N58 VSS VSS lpnfet L=0.12U W=3.32U
m42 AP0-AIND0 N57 VDD VDD lppfet L=0.12U W=4.16U
m43 N93 N57 N94 VSS lpnfet L=0.12U W=3.32U
m44 AP0-AIND0 AP0-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m45 AP0-AIND0 AP0-AIN20 N93 VSS lpnfet L=0.12U W=3.32U
m46 AP0-APN1 AY0_ VDD VDD lppfet L=0.2U W=0.16U
m47 AP0-APN1 AY0_ VSS VSS lpnfet L=0.39U W=0.16U
m48 AY0_ AP0-APN1 VDD VDD lppfet L=0.12U W=13.74U
m49 AY0_ AP0-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m5 N43 A0 VDD VDD lppfet L=0.12U W=1.84U
m50 AP0-APN0 AY0 VDD VDD lppfet L=0.2U W=0.16U
m51 AP0-APN0 AY0 VSS VSS lpnfet L=0.39U W=0.16U
m52 AY0 AP0-APN0 VDD VDD lppfet L=0.12U W=13.74U
m53 AY0 AP0-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m54 AP_I1-APN1 N105 AP_I1-AIND1 VSS lpnfet L=0.12U W=3.32U
m55 AP_I1-APN1 AGTP AP_I1-AIND1 VDD lppfet L=0.12U W=4.15U
m56 N105 AGTP VDD VDD lppfet L=0.12U W=0.58U
m57 N105 AGTP VSS VSS lpnfet L=0.12U W=0.5U
m58 AP_I1-AIN21 N37 VDD VDD lppfet L=0.12U W=2.03U
m59 AP_I1-AIN21 N37 VSS VSS lpnfet L=0.12U W=1.34U
m6 N43 A0 VSS VSS lpnfet L=0.12U W=1.24U
m60 N99 VSS VDD VDD lppfet L=0.12U W=2.03U
m61 N99 VSS VSS VSS lpnfet L=0.12U W=1.34U
m62 N100 VSS VDD VDD lppfet L=0.12U W=2.03U
m63 N100 VSS VSS VSS lpnfet L=0.12U W=1.34U
m64 N134 N100 VSS VSS lpnfet L=0.12U W=3.32U
m65 N133 N99 N134 VSS lpnfet L=0.12U W=3.32U
m66 AP_I1-AIND1 AP_I1-AIN21 N133 VSS lpnfet L=0.12U W=3.32U
m67 AP_I1-AIND1 N100 VDD VDD lppfet L=0.12U W=4.16U
m68 N132 N100 VSS VSS lpnfet L=0.12U W=3.32U
m69 AP_I1-AIND1 N99 VDD VDD lppfet L=0.12U W=4.16U
m70 N131 N99 N132 VSS lpnfet L=0.12U W=3.32U
m71 AP_I1-AIND1 AP_I1-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m72 AP_I1-AIND1 AP_I1-AIN21 N131 VSS lpnfet L=0.12U W=3.32U
m73 AP_I1-APN0 N116 AP_I1-AIND0 VSS lpnfet L=0.12U W=3.32U
m74 AP_I1-APN0 AGTP AP_I1-AIND0 VDD lppfet L=0.12U W=4.15U
m75 N116 AGTP VDD VDD lppfet L=0.12U W=0.58U
m76 N116 AGTP VSS VSS lpnfet L=0.12U W=0.5U
m77 AP_I1-AIN20 N36 VDD VDD lppfet L=0.12U W=2.03U
m78 AP_I1-AIN20 N36 VSS VSS lpnfet L=0.12U W=1.34U
m79 N138 N100 VSS VSS lpnfet L=0.12U W=3.32U
m80 N137 N99 N138 VSS lpnfet L=0.12U W=3.32U
m81 AP_I1-AIND0 AP_I1-AIN20 N137 VSS lpnfet L=0.12U W=3.32U
m82 AP_I1-AIND0 N100 VDD VDD lppfet L=0.12U W=4.16U
m83 N136 N100 VSS VSS lpnfet L=0.12U W=3.32U
m84 AP_I1-AIND0 N99 VDD VDD lppfet L=0.12U W=4.16U
m85 N135 N99 N136 VSS lpnfet L=0.12U W=3.32U
m86 AP_I1-AIND0 AP_I1-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m87 AP_I1-AIND0 AP_I1-AIN20 N135 VSS lpnfet L=0.12U W=3.32U
m88 AP_I1-APN1 AY0_ VDD VDD lppfet L=0.2U W=0.16U
m89 AP_I1-APN1 AY0_ VSS VSS lpnfet L=0.39U W=0.16U
m90 AY0_ AP_I1-APN1 VDD VDD lppfet L=0.12U W=13.74U
m91 AY0_ AP_I1-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m92 AP_I1-APN0 AY0 VDD VDD lppfet L=0.2U W=0.16U
m93 AP_I1-APN0 AY0 VSS VSS lpnfet L=0.39U W=0.16U
m94 AY0 AP_I1-APN0 VDD VDD lppfet L=0.12U W=13.74U
m95 AY0 AP_I1-APN0 VSS VSS lpnfet L=0.12U W=9.48U
.ENDS Mem_cnnin2HYP12XR
****
.SUBCKT Mem_cnnin2HYP12XRX_B A0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK
+  GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS
** Mem_cnnin2HYP12XRX_B: 95 flat devices **
XI0_0 A0 AGTP AY0B AY0A AY0A_ AY0B AY0B_ AY0B_ BWENA BWENB CLK GSRCN GTPN
+  OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2HYP12XR
.ENDS Mem_cnnin2HYP12XRX_B
****
.SUBCKT Mem_cnnin2Y_DECODEB A0_0 A0_1 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD
+  VSS
** Mem_cnnin2Y_DECODEB: 190 flat devices **
XI0_0 A0_0 AGTP AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS Mem_cnnin2HYP12XLX_B
XI1_0 A0_1 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK GSRCN GTPN OEIA_ OEIB_
+  RST WEIA WEIB YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS
+  VSS VSS VSS VSS VDD VSS Mem_cnnin2HYP12XRX_B
.ENDS Mem_cnnin2Y_DECODEB
****
.SUBCKT Mem_cnnin2WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 WLA0 WLA1 WLB0 WLB1 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WD: 30 flat devices **
m1 N29 RSWN0 GTP VDD lppfet L=0.12U W=2.6U
m10 WL0 WL0_EN_ VSS VSS lpnfet L=0.12U W=9.36U
m11 N28 RSWN1 GTP VDD lppfet L=0.12U W=2.6U
m12 N28 WLI1 GTP VSS lpnfet L=0.12U W=0.7U
m13 N37 G0 VSS VSS lpnfet L=0.12U W=0.71U
m14 N38 G1 N37 VSS lpnfet L=0.12U W=0.71U
m15 RSWN1 G2_W1 N38 VSS lpnfet L=0.12U W=0.71U
m16 RSWN1 G0 VDD VDD lppfet L=0.12U W=0.41U
m17 RSWN1 G2_W1 VDD VDD lppfet L=0.12U W=0.41U
m18 RSWN1 G1 VDD VDD lppfet L=0.12U W=0.41U
m19 WL1 WL1_EN_ VDD VDD lppfet L=0.12U W=28.44U
m2 N29 WLI0 GTP VSS lpnfet L=0.12U W=0.7U
m20 WL1 WL1_EN_ VSS VSS lpnfet L=0.12U W=9.36U
m21 WLI1 RSWN1 VDD VDD lppfet L=0.12U W=0.29U
m22 WLI1 RSWN1 VSS VSS lpnfet L=0.12U W=0.19U
m23 WLI0 RSWN0 VDD VDD lppfet L=0.12U W=0.29U
m24 WLI0 RSWN0 VSS VSS lpnfet L=0.12U W=0.19U
m25 N28 RSWN1 VSS VSS lpnfet L=0.12U W=0.3U
m26 N29 RSWN0 VSS VSS lpnfet L=0.12U W=0.3U
m27 WL1_EN_ N28 VDD VDD lppfet L=0.12U W=6.36U
m28 WL1_EN_ N28 VSS VSS lpnfet L=0.12U W=9.66U
m29 WL0_EN_ N29 VDD VDD lppfet L=0.12U W=6.36U
m3 N30 G0 VSS VSS lpnfet L=0.12U W=0.71U
m30 WL0_EN_ N29 VSS VSS lpnfet L=0.12U W=9.66U
m4 N31 G1 N30 VSS lpnfet L=0.12U W=0.71U
m5 RSWN0 G2_W0 N31 VSS lpnfet L=0.12U W=0.71U
m6 RSWN0 G0 VDD VDD lppfet L=0.12U W=0.41U
m7 RSWN0 G2_W0 VDD VDD lppfet L=0.12U W=0.41U
m8 RSWN0 G1 VDD VDD lppfet L=0.12U W=0.41U
m9 WL0 WL0_EN_ VDD VDD lppfet L=0.12U W=28.44U
.ENDS Mem_cnnin2WD
****
.SUBCKT Mem_cnnin2WDX_0_B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_0_B: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_0_B
****
.SUBCKT Mem_cnnin2ROW_8B G0 G1 G1B GTP WLA0 WLA1 WLB0 WLB1 XP0F_0 XP0F_1
+  XP0F_2 XP0F_3 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_8B: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_0_B
.ENDS Mem_cnnin2ROW_8B
****
.SUBCKT Mem_cnnin2WDX_1_B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_1_B: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_1_B
****
.SUBCKT Mem_cnnin2ROW_FILLER1B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER1B: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_1_B
.ENDS Mem_cnnin2ROW_FILLER1B
****
.SUBCKT Mem_cnnin2WDX_2_B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_2_B: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_2_B
****
.SUBCKT Mem_cnnin2ROW_FILLER2B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER2B: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_2_B
.ENDS Mem_cnnin2ROW_FILLER2B
****
.SUBCKT Mem_cnnin2WDX_3_B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_3_B: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_3_B
****
.SUBCKT Mem_cnnin2ROW_FILLER3B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER3B: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_3_B
.ENDS Mem_cnnin2ROW_FILLER3B
****
.SUBCKT Mem_cnnin2HWDB G0 G1 G2_W0 G2_W1 GTP0 GTP1 GTP2 GTP3 GTP4 GTPA GTPB
+  WL0 WL1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VDD VSS
** Mem_cnnin2HWDB: 30 flat devices **
m1 N35 WD_I0-RSWN0 GTP4 VDD lppfet L=0.12U W=2.6U
m10 WL0 WD_I0-WL0_EN_ VSS VSS lpnfet L=0.12U W=9.36U
m11 N34 WD_I0-RSWN1 GTP4 VDD lppfet L=0.12U W=2.6U
m12 N34 WD_I0-WLI1 GTP4 VSS lpnfet L=0.12U W=0.7U
m13 N43 G0 VSS VSS lpnfet L=0.12U W=0.71U
m14 N44 G1 N43 VSS lpnfet L=0.12U W=0.71U
m15 WD_I0-RSWN1 G2_W1 N44 VSS lpnfet L=0.12U W=0.71U
m16 WD_I0-RSWN1 G0 VDD VDD lppfet L=0.12U W=0.41U
m17 WD_I0-RSWN1 G2_W1 VDD VDD lppfet L=0.12U W=0.41U
m18 WD_I0-RSWN1 G1 VDD VDD lppfet L=0.12U W=0.41U
m19 WL1 WD_I0-WL1_EN_ VDD VDD lppfet L=0.12U W=28.44U
m2 N35 WD_I0-WLI0 GTP4 VSS lpnfet L=0.12U W=0.7U
m20 WL1 WD_I0-WL1_EN_ VSS VSS lpnfet L=0.12U W=9.36U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD lppfet L=0.12U W=0.29U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS lpnfet L=0.12U W=0.19U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD lppfet L=0.12U W=0.29U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS lpnfet L=0.12U W=0.19U
m25 N34 WD_I0-RSWN1 VSS VSS lpnfet L=0.12U W=0.3U
m26 N35 WD_I0-RSWN0 VSS VSS lpnfet L=0.12U W=0.3U
m27 WD_I0-WL1_EN_ N34 VDD VDD lppfet L=0.12U W=6.36U
m28 WD_I0-WL1_EN_ N34 VSS VSS lpnfet L=0.12U W=9.66U
m29 WD_I0-WL0_EN_ N35 VDD VDD lppfet L=0.12U W=6.36U
m3 N36 G0 VSS VSS lpnfet L=0.12U W=0.71U
m30 WD_I0-WL0_EN_ N35 VSS VSS lpnfet L=0.12U W=9.66U
m4 N37 G1 N36 VSS lpnfet L=0.12U W=0.71U
m5 WD_I0-RSWN0 G2_W0 N37 VSS lpnfet L=0.12U W=0.71U
m6 WD_I0-RSWN0 G0 VDD VDD lppfet L=0.12U W=0.41U
m7 WD_I0-RSWN0 G2_W0 VDD VDD lppfet L=0.12U W=0.41U
m8 WD_I0-RSWN0 G1 VDD VDD lppfet L=0.12U W=0.41U
m9 WL0 WD_I0-WL0_EN_ VDD VDD lppfet L=0.12U W=28.44U
.ENDS Mem_cnnin2HWDB
****
.SUBCKT Mem_cnnin2HWDBX_B G0 G1 G2_W0 G2_W1 GTPA GTPB WLA0 WLA1 WLB0 WLB1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2HWDBX_B: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTPB GTPB GTPB GTPB GTPB GTPA GTPB WLB0 WLB1 WLA0 WLA1
+  WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2HWDB
.ENDS Mem_cnnin2HWDBX_B
****
.SUBCKT Mem_cnnin2HWDBX_B0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2HWDBX_B0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2HWDBX_B
.ENDS Mem_cnnin2HWDBX_B0
****
.SUBCKT Mem_cnnin2ROW_BOTTOMB G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0F_0
+  XP0F_1 XP0F_2 XP0F_3 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_BOTTOMB: 30 flat devices **
XI4_0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS Mem_cnnin2HWDBX_B0
.ENDS Mem_cnnin2ROW_BOTTOMB
****
.SUBCKT Mem_cnnin2FCMWDX MWLA MWLB XP0 XP1 VDD VSS
** Mem_cnnin2FCMWDX: 2 flat devices **
d1 VSS XP1 tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS XP0 tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCMWDX
****
.SUBCKT Mem_cnnin2FCMWD G0F G1F MWLA MWLB XP0F XP1F VDD VSS
** Mem_cnnin2FCMWD: 2 flat devices **
d1 VSS XP1F tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS XP0F tdndsx AREA=0.1024P PERIM=1.28U
.ENDS Mem_cnnin2FCMWD
****
.SUBCKT Mem_cnnin2MWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7
+  MWG8 MWG9 MWG10 MWG11 MWL MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2MWD: 41 flat devices **
m1 MWL N60 VDD VDD lppfet L=0.12U W=24.42U
m10 MBL MWG1 VSS VSS lpnfet L=0.12U W=0.16U
m11 MBL MWG0 VSS VSS lpnfet L=0.12U W=0.16U
m12 MBL MWG1 VSS VSS lpnfet L=0.12U W=0.16U
m13 MBL MWG0 VSS VSS lpnfet L=0.12U W=0.16U
m14 MBL MWG3 VSS VSS lpnfet L=0.12U W=0.16U
m15 MBL MWG2 VSS VSS lpnfet L=0.12U W=0.16U
m16 MBL MWG3 VSS VSS lpnfet L=0.12U W=0.16U
m17 MBL MWG2 VSS VSS lpnfet L=0.12U W=0.16U
m18 MBL MWG5 VSS VSS lpnfet L=0.12U W=0.16U
m19 MBL MWG4 VSS VSS lpnfet L=0.12U W=0.16U
m2 MWL N60 VSS VSS lpnfet L=0.12U W=15.04U
m20 MBL MWG5 VSS VSS lpnfet L=0.12U W=0.16U
m21 MBL MWG4 VSS VSS lpnfet L=0.12U W=0.16U
m22 MBL MWG7 VSS VSS lpnfet L=0.12U W=0.16U
m23 MBL MWG6 VSS VSS lpnfet L=0.12U W=0.16U
m24 MBL MWG7 VSS VSS lpnfet L=0.12U W=0.16U
m25 MBL MWG6 VSS VSS lpnfet L=0.12U W=0.16U
m26 MBL MWG9 VSS VSS lpnfet L=0.12U W=0.16U
m27 MBL MWG8 VSS VSS lpnfet L=0.12U W=0.16U
m28 MBL MWG9 VSS VSS lpnfet L=0.12U W=0.16U
m29 MBL MWG8 VSS VSS lpnfet L=0.12U W=0.16U
m3 N60 N63 VDD VDD lppfet L=0.12U W=10.21U
m30 MBL MWG11 VSS VSS lpnfet L=0.12U W=0.16U
m31 MBL MWG10 VSS VSS lpnfet L=0.12U W=0.16U
m32 MBL MWG11 VSS VSS lpnfet L=0.12U W=0.16U
m33 MBL MWG10 VSS VSS lpnfet L=0.12U W=0.16U
m34 MBL MWLD VSS VSS lpnfet L=0.12U W=0.16U
m35 MBL MWLD VSS VSS lpnfet L=0.12U W=0.16U
m36 MBL MWLD VSS VSS lpnfet L=0.12U W=0.16U
m37 MBL MWLD VSS VSS lpnfet L=0.12U W=0.16U
m38 N63 N68 VDD VDD lppfet L=0.26U W=2.64U
m39 N63 N68 VSS VSS lpnfet L=0.26U W=1.7U
m4 N60 N63 VSS VSS lpnfet L=0.12U W=6.53U
m40 N68 N59 VDD VDD lppfet L=0.26U W=1.7U
m41 N68 N59 VSS VSS lpnfet L=0.26U W=0.9U
m5 MBL GTP VDD VDD lppfet L=0.12U W=5.38U
m6 MBL_ GTP VDD VDD lppfet L=0.12U W=5.38U
m7 MBL GTP MBL_ VDD lppfet L=0.12U W=5.38U
m8 N59 VSS GTP VDD lppfet L=0.26U W=0.9U
m9 N59 VDD GTP VSS lpnfet L=0.26U W=0.9U
.ENDS Mem_cnnin2MWD
****
.SUBCKT Mem_cnnin2MWDX_B GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2MWDX_B: 41 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS MWLB
+  MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2MWD
.ENDS Mem_cnnin2MWDX_B
****
.SUBCKT Mem_cnnin2ROW_TOPB G0F G1F GTP MBL MBL_ MWLA MWLB MWLD XP0F XP0_0
+  XP0_1 XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_TOPB: 49 flat devices **
XI0_0 MWLA MWLB XP0_0 XP1_0 VDD VSS Mem_cnnin2FCMWDX
XI1_0 MWLA MWLB XP0_1 XP1_1 VDD VSS Mem_cnnin2FCMWDX
XI2_0 MWLA MWLB XP0_2 XP1_2 VDD VSS Mem_cnnin2FCMWDX
XI3_0 G0F G1F MWLA MWLB XP0F XP1F VDD VSS Mem_cnnin2FCMWD
XI4_0 GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2MWDX_B
.ENDS Mem_cnnin2ROW_TOPB
****
.SUBCKT Mem_cnnin2WORD_ROWSB G0 GTPA GTPB MBL MBL_ MWLA MWLB MWLD WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19
+  WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28
+  WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6
+  WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15
+  WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24
+  WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1
+  WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11
+  WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20
+  WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29
+  WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7
+  WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16
+  WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25
+  WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS
** Mem_cnnin2WORD_ROWSB: 1009 flat devices **
XI0_0 G0 XP0_3 GTPA GTPB WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_BOTTOMB
XI0_1 G0 XP0_3 GTPB WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1B
XI0_10 G0 XP0_2 GTPB WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_11 G0 XP0_2 GTPB WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_12 G0 XP1_2 XP0_2 GTPB WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8B
XI0_13 G0 XP1_2 GTPB WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1B
XI0_14 G0 XP1_2 GTPB WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_15 G0 XP1_2 GTPB WLA0_15 WLA1_15 WLB0_15 WLB1_15 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_17 G0 XP0_1 XP1_2 GTPB WLA0_16 WLA1_16 WLB0_16 WLB1_16 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8B
XI0_18 G0 XP0_1 GTPB WLA0_17 WLA1_17 WLB0_17 WLB1_17 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1B
XI0_19 G0 XP0_1 GTPB WLA0_18 WLA1_18 WLB0_18 WLB1_18 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_2 G0 XP0_3 GTPB WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER2B
XI0_20 G0 XP0_1 GTPB WLA0_19 WLA1_19 WLB0_19 WLB1_19 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_21 G0 XP1_1 XP0_1 GTPB WLA0_20 WLA1_20 WLB0_20 WLB1_20 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8B
XI0_22 G0 XP1_1 GTPB WLA0_21 WLA1_21 WLB0_21 WLB1_21 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1B
XI0_23 G0 XP1_1 GTPB WLA0_22 WLA1_22 WLB0_22 WLB1_22 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_24 G0 XP1_1 GTPB WLA0_23 WLA1_23 WLB0_23 WLB1_23 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_25 G0 XP0_0 XP1_1 GTPB WLA0_24 WLA1_24 WLB0_24 WLB1_24 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8B
XI0_26 G0 XP0_0 GTPB WLA0_25 WLA1_25 WLB0_25 WLB1_25 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1B
XI0_27 G0 XP0_0 GTPB WLA0_26 WLA1_26 WLB0_26 WLB1_26 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_28 G0 XP0_0 GTPB WLA0_27 WLA1_27 WLB0_27 WLB1_27 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_29 G0 XP1_0 XP0_0 GTPB WLA0_28 WLA1_28 WLB0_28 WLB1_28 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8B
XI0_3 G0 XP0_3 GTPB WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER3B
XI0_30 G0 XP1_0 GTPB WLA0_29 WLA1_29 WLB0_29 WLB1_29 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1B
XI0_31 G0 XP1_0 GTPB WLA0_30 WLA1_30 WLB0_30 WLB1_30 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2B
XI0_32 G0 XP1_0 GTPB WLA0_31 WLA1_31 WLB0_31 WLB1_31 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3B
XI0_33 G0 XP1_0 GTPB MBL MBL_ MWLA MWLB MWLD XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_TOPB
XI0_4 G0 XP1_3 XP0_3 GTPB WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_8B
XI0_5 G0 XP1_3 GTPB WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1B
XI0_6 G0 XP1_3 GTPB WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER2B
XI0_7 G0 XP1_3 GTPB WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER3B
XI0_8 G0 XP0_2 XP1_3 GTPB WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_8B
XI0_9 G0 XP0_2 GTPB WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1B
.ENDS Mem_cnnin2WORD_ROWSB
****
.SUBCKT Mem_cnnin2HXP38 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2HXP38: 201 flat devices **
d175 VSS A2 tdndsx AREA=0.1024P PERIM=1.28U
d176 VSS WEIA tdndsx AREA=0.1024P PERIM=1.28U
d177 VSS WEIB tdndsx AREA=0.1024P PERIM=1.28U
d178 VSS BWENA tdndsx AREA=0.1024P PERIM=1.28U
d179 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
d186 VSS A1 tdndsx AREA=0.1024P PERIM=1.28U
d187 VSS WEIA tdndsx AREA=0.1024P PERIM=1.28U
d188 VSS WEIB tdndsx AREA=0.1024P PERIM=1.28U
d189 VSS BWENA tdndsx AREA=0.1024P PERIM=1.28U
d190 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
d197 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d198 VSS WEIA tdndsx AREA=0.1024P PERIM=1.28U
d199 VSS WEIB tdndsx AREA=0.1024P PERIM=1.28U
d200 VSS BWENA tdndsx AREA=0.1024P PERIM=1.28U
d201 VSS BWENB tdndsx AREA=0.1024P PERIM=1.28U
m1 AP67-APN1 N69 AP67-AIND1 VSS lpnfet L=0.12U W=3.32U
m10 N64 AI2_ VSS VSS lpnfet L=0.12U W=1.34U
m100 AP23-AIND1 N147 VDD VDD lppfet L=0.12U W=4.16U
m101 N179 N147 N180 VSS lpnfet L=0.12U W=3.32U
m102 AP23-AIND1 AP23-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m103 AP23-AIND1 AP23-AIN21 N179 VSS lpnfet L=0.12U W=3.32U
m104 AP23-APN0 N164 AP23-AIND0 VSS lpnfet L=0.12U W=3.32U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD lppfet L=0.12U W=4.15U
m106 N164 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m107 N164 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m108 AP23-AIN20 AI0 VDD VDD lppfet L=0.12U W=2.03U
m109 AP23-AIN20 AI0 VSS VSS lpnfet L=0.12U W=1.34U
m11 N98 N64 VSS VSS lpnfet L=0.12U W=3.32U
m110 N186 N148 VSS VSS lpnfet L=0.12U W=3.32U
m111 N185 N147 N186 VSS lpnfet L=0.12U W=3.32U
m112 AP23-AIND0 AP23-AIN20 N185 VSS lpnfet L=0.12U W=3.32U
m113 AP23-AIND0 N148 VDD VDD lppfet L=0.12U W=4.16U
m114 N184 N148 VSS VSS lpnfet L=0.12U W=3.32U
m115 AP23-AIND0 N147 VDD VDD lppfet L=0.12U W=4.16U
m116 N183 N147 N184 VSS lpnfet L=0.12U W=3.32U
m117 AP23-AIND0 AP23-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m118 AP23-AIND0 AP23-AIN20 N183 VSS lpnfet L=0.12U W=3.32U
m119 AP23-APN1 XP_3 VDD VDD lppfet L=0.2U W=0.16U
m12 N97 N63 N98 VSS lpnfet L=0.12U W=3.32U
m120 AP23-APN1 XP_3 VSS VSS lpnfet L=0.39U W=0.16U
m121 XP_3 AP23-APN1 VDD VDD lppfet L=0.12U W=13.74U
m122 XP_3 AP23-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m123 AP23-APN0 XP_2 VDD VDD lppfet L=0.2U W=0.16U
m124 AP23-APN0 XP_2 VSS VSS lpnfet L=0.39U W=0.16U
m125 XP_2 AP23-APN0 VDD VDD lppfet L=0.12U W=13.74U
m126 XP_2 AP23-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m127 AP01-APN1 N195 AP01-AIND1 VSS lpnfet L=0.12U W=3.32U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD lppfet L=0.12U W=4.15U
m129 N195 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m13 AP67-AIND1 AP67-AIN21 N97 VSS lpnfet L=0.12U W=3.32U
m130 N195 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m131 AP01-AIN21 AI0_ VDD VDD lppfet L=0.12U W=2.03U
m132 AP01-AIN21 AI0_ VSS VSS lpnfet L=0.12U W=1.34U
m133 N189 AI1 VDD VDD lppfet L=0.12U W=2.03U
m134 N189 AI1 VSS VSS lpnfet L=0.12U W=1.34U
m135 N190 AI2 VDD VDD lppfet L=0.12U W=2.03U
m136 N190 AI2 VSS VSS lpnfet L=0.12U W=1.34U
m137 N224 N190 VSS VSS lpnfet L=0.12U W=3.32U
m138 N223 N189 N224 VSS lpnfet L=0.12U W=3.32U
m139 AP01-AIND1 AP01-AIN21 N223 VSS lpnfet L=0.12U W=3.32U
m14 AP67-AIND1 N64 VDD VDD lppfet L=0.12U W=4.16U
m140 AP01-AIND1 N190 VDD VDD lppfet L=0.12U W=4.16U
m141 N222 N190 VSS VSS lpnfet L=0.12U W=3.32U
m142 AP01-AIND1 N189 VDD VDD lppfet L=0.12U W=4.16U
m143 N221 N189 N222 VSS lpnfet L=0.12U W=3.32U
m144 AP01-AIND1 AP01-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m145 AP01-AIND1 AP01-AIN21 N221 VSS lpnfet L=0.12U W=3.32U
m146 AP01-APN0 N206 AP01-AIND0 VSS lpnfet L=0.12U W=3.32U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD lppfet L=0.12U W=4.15U
m148 N206 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m149 N206 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m15 N96 N64 VSS VSS lpnfet L=0.12U W=3.32U
m150 AP01-AIN20 AI0 VDD VDD lppfet L=0.12U W=2.03U
m151 AP01-AIN20 AI0 VSS VSS lpnfet L=0.12U W=1.34U
m152 N228 N190 VSS VSS lpnfet L=0.12U W=3.32U
m153 N227 N189 N228 VSS lpnfet L=0.12U W=3.32U
m154 AP01-AIND0 AP01-AIN20 N227 VSS lpnfet L=0.12U W=3.32U
m155 AP01-AIND0 N190 VDD VDD lppfet L=0.12U W=4.16U
m156 N226 N190 VSS VSS lpnfet L=0.12U W=3.32U
m157 AP01-AIND0 N189 VDD VDD lppfet L=0.12U W=4.16U
m158 N225 N189 N226 VSS lpnfet L=0.12U W=3.32U
m159 AP01-AIND0 AP01-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m16 AP67-AIND1 N63 VDD VDD lppfet L=0.12U W=4.16U
m160 AP01-AIND0 AP01-AIN20 N225 VSS lpnfet L=0.12U W=3.32U
m161 AP01-APN1 XP_1 VDD VDD lppfet L=0.2U W=0.16U
m162 AP01-APN1 XP_1 VSS VSS lpnfet L=0.39U W=0.16U
m163 XP_1 AP01-APN1 VDD VDD lppfet L=0.12U W=13.74U
m164 XP_1 AP01-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m165 AP01-APN0 XP_0 VDD VDD lppfet L=0.2U W=0.16U
m166 AP01-APN0 XP_0 VSS VSS lpnfet L=0.39U W=0.16U
m167 XP_0 AP01-APN0 VDD VDD lppfet L=0.12U W=13.74U
m168 XP_0 AP01-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m169 AI2 N229 VDD VDD lppfet L=0.12U W=2.3U
m17 N95 N63 N96 VSS lpnfet L=0.12U W=3.32U
m170 AI2 N229 VSS VSS lpnfet L=0.12U W=1.54U
m171 AI2_ A2 VDD VDD lppfet L=0.12U W=2.3U
m172 AI2_ A2 VSS VSS lpnfet L=0.12U W=1.54U
m173 N229 A2 VDD VDD lppfet L=0.12U W=1.84U
m174 N229 A2 VSS VSS lpnfet L=0.12U W=1.24U
m18 AP67-AIND1 AP67-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m180 AI1 N241 VDD VDD lppfet L=0.12U W=2.3U
m181 AI1 N241 VSS VSS lpnfet L=0.12U W=1.54U
m182 AI1_ A1 VDD VDD lppfet L=0.12U W=2.3U
m183 AI1_ A1 VSS VSS lpnfet L=0.12U W=1.54U
m184 N241 A1 VDD VDD lppfet L=0.12U W=1.84U
m185 N241 A1 VSS VSS lpnfet L=0.12U W=1.24U
m19 AP67-AIND1 AP67-AIN21 N95 VSS lpnfet L=0.12U W=3.32U
m191 AI0 N253 VDD VDD lppfet L=0.12U W=2.3U
m192 AI0 N253 VSS VSS lpnfet L=0.12U W=1.54U
m193 AI0_ A0 VDD VDD lppfet L=0.12U W=2.3U
m194 AI0_ A0 VSS VSS lpnfet L=0.12U W=1.54U
m195 N253 A0 VDD VDD lppfet L=0.12U W=1.84U
m196 N253 A0 VSS VSS lpnfet L=0.12U W=1.24U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD lppfet L=0.12U W=4.15U
m20 AP67-APN0 N80 AP67-AIND0 VSS lpnfet L=0.12U W=3.32U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD lppfet L=0.12U W=4.15U
m22 N80 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m23 N80 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m24 AP67-AIN20 AI0 VDD VDD lppfet L=0.12U W=2.03U
m25 AP67-AIN20 AI0 VSS VSS lpnfet L=0.12U W=1.34U
m26 N102 N64 VSS VSS lpnfet L=0.12U W=3.32U
m27 N101 N63 N102 VSS lpnfet L=0.12U W=3.32U
m28 AP67-AIND0 AP67-AIN20 N101 VSS lpnfet L=0.12U W=3.32U
m29 AP67-AIND0 N64 VDD VDD lppfet L=0.12U W=4.16U
m3 N69 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m30 N100 N64 VSS VSS lpnfet L=0.12U W=3.32U
m31 AP67-AIND0 N63 VDD VDD lppfet L=0.12U W=4.16U
m32 N99 N63 N100 VSS lpnfet L=0.12U W=3.32U
m33 AP67-AIND0 AP67-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m34 AP67-AIND0 AP67-AIN20 N99 VSS lpnfet L=0.12U W=3.32U
m35 AP67-APN1 XP_7 VDD VDD lppfet L=0.2U W=0.16U
m36 AP67-APN1 XP_7 VSS VSS lpnfet L=0.39U W=0.16U
m37 XP_7 AP67-APN1 VDD VDD lppfet L=0.12U W=13.74U
m38 XP_7 AP67-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m39 AP67-APN0 XP_6 VDD VDD lppfet L=0.2U W=0.16U
m4 N69 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m40 AP67-APN0 XP_6 VSS VSS lpnfet L=0.39U W=0.16U
m41 XP_6 AP67-APN0 VDD VDD lppfet L=0.12U W=13.74U
m42 XP_6 AP67-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m43 AP45-APN1 N111 AP45-AIND1 VSS lpnfet L=0.12U W=3.32U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD lppfet L=0.12U W=4.15U
m45 N111 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m46 N111 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m47 AP45-AIN21 AI0_ VDD VDD lppfet L=0.12U W=2.03U
m48 AP45-AIN21 AI0_ VSS VSS lpnfet L=0.12U W=1.34U
m49 N105 AI1 VDD VDD lppfet L=0.12U W=2.03U
m5 AP67-AIN21 AI0_ VDD VDD lppfet L=0.12U W=2.03U
m50 N105 AI1 VSS VSS lpnfet L=0.12U W=1.34U
m51 N106 AI2_ VDD VDD lppfet L=0.12U W=2.03U
m52 N106 AI2_ VSS VSS lpnfet L=0.12U W=1.34U
m53 N140 N106 VSS VSS lpnfet L=0.12U W=3.32U
m54 N139 N105 N140 VSS lpnfet L=0.12U W=3.32U
m55 AP45-AIND1 AP45-AIN21 N139 VSS lpnfet L=0.12U W=3.32U
m56 AP45-AIND1 N106 VDD VDD lppfet L=0.12U W=4.16U
m57 N138 N106 VSS VSS lpnfet L=0.12U W=3.32U
m58 AP45-AIND1 N105 VDD VDD lppfet L=0.12U W=4.16U
m59 N137 N105 N138 VSS lpnfet L=0.12U W=3.32U
m6 AP67-AIN21 AI0_ VSS VSS lpnfet L=0.12U W=1.34U
m60 AP45-AIND1 AP45-AIN21 VDD VDD lppfet L=0.12U W=4.16U
m61 AP45-AIND1 AP45-AIN21 N137 VSS lpnfet L=0.12U W=3.32U
m62 AP45-APN0 N122 AP45-AIND0 VSS lpnfet L=0.12U W=3.32U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD lppfet L=0.12U W=4.15U
m64 N122 AGTPB VDD VDD lppfet L=0.12U W=0.58U
m65 N122 AGTPB VSS VSS lpnfet L=0.12U W=0.5U
m66 AP45-AIN20 AI0 VDD VDD lppfet L=0.12U W=2.03U
m67 AP45-AIN20 AI0 VSS VSS lpnfet L=0.12U W=1.34U
m68 N144 N106 VSS VSS lpnfet L=0.12U W=3.32U
m69 N143 N105 N144 VSS lpnfet L=0.12U W=3.32U
m7 N63 AI1_ VDD VDD lppfet L=0.12U W=2.03U
m70 AP45-AIND0 AP45-AIN20 N143 VSS lpnfet L=0.12U W=3.32U
m71 AP45-AIND0 N106 VDD VDD lppfet L=0.12U W=4.16U
m72 N142 N106 VSS VSS lpnfet L=0.12U W=3.32U
m73 AP45-AIND0 N105 VDD VDD lppfet L=0.12U W=4.16U
m74 N141 N105 N142 VSS lpnfet L=0.12U W=3.32U
m75 AP45-AIND0 AP45-AIN20 VDD VDD lppfet L=0.12U W=4.16U
m76 AP45-AIND0 AP45-AIN20 N141 VSS lpnfet L=0.12U W=3.32U
m77 AP45-APN1 XP_5 VDD VDD lppfet L=0.2U W=0.16U
m78 AP45-APN1 XP_5 VSS VSS lpnfet L=0.39U W=0.16U
m79 XP_5 AP45-APN1 VDD VDD lppfet L=0.12U W=13.74U
m8 N63 AI1_ VSS VSS lpnfet L=0.12U W=1.34U
m80 XP_5 AP45-APN1 VSS VSS lpnfet L=0.12U W=9.48U
m81 AP45-APN0 XP_4 VDD VDD lppfet L=0.2U W=0.16U
m82 AP45-APN0 XP_4 VSS VSS lpnfet L=0.39U W=0.16U
m83 XP_4 AP45-APN0 VDD VDD lppfet L=0.12U W=13.74U
m84 XP_4 AP45-APN0 VSS VSS lpnfet L=0.12U W=9.48U
m85 AP23-APN1 N153 AP23-AIND1 VSS lpnfet L=0.12U W=3.32U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD lppfet L=0.12U W=4.15U
m87 N153 AGTPT VDD VDD lppfet L=0.12U W=0.58U
m88 N153 AGTPT VSS VSS lpnfet L=0.12U W=0.5U
m89 AP23-AIN21 AI0_ VDD VDD lppfet L=0.12U W=2.03U
m9 N64 AI2_ VDD VDD lppfet L=0.12U W=2.03U
m90 AP23-AIN21 AI0_ VSS VSS lpnfet L=0.12U W=1.34U
m91 N147 AI1_ VDD VDD lppfet L=0.12U W=2.03U
m92 N147 AI1_ VSS VSS lpnfet L=0.12U W=1.34U
m93 N148 AI2 VDD VDD lppfet L=0.12U W=2.03U
m94 N148 AI2 VSS VSS lpnfet L=0.12U W=1.34U
m95 N182 N148 VSS VSS lpnfet L=0.12U W=3.32U
m96 N181 N147 N182 VSS lpnfet L=0.12U W=3.32U
m97 AP23-AIND1 AP23-AIN21 N181 VSS lpnfet L=0.12U W=3.32U
m98 AP23-AIND1 N148 VDD VDD lppfet L=0.12U W=4.16U
m99 N180 N148 VSS VSS lpnfet L=0.12U W=3.32U
.ENDS Mem_cnnin2HXP38
****
.SUBCKT Mem_cnnin2HXP38X_B A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA
+  BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2HXP38X_B: 201 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38
.ENDS Mem_cnnin2HXP38X_B
****
.SUBCKT Mem_cnnin2X_PRE_DECODEB A0_0 A0_1 A1_0 A1_1 A2_0 A2_1 AGTPB AGTPT AY0A
+  AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB XP_0_0 XP_0_1 XP_1_0
+  XP_1_1 XP_2_0 XP_2_1 XP_3_0 XP_3_1 XP_4_0 XP_4_1 XP_5_0 XP_5_1 XP_6_0
+  XP_6_1 XP_7_0 XP_7_1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2X_PRE_DECODEB: 402 flat devices **
XI0_0 A0_0 A1_0 A2_0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38X_B
XI1_0 A0_1 A1_1 A2_1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_1 XP_1_1 XP_2_1 XP_3_1 XP_4_1 XP_5_1 XP_6_1 XP_7_1 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38X_B
.ENDS Mem_cnnin2X_PRE_DECODEB
****
.SUBCKT Mem_cnnin2MODEL_COL_B BLB BLB_ MWLAS MWLBD MWLBS MWLD WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDD VSS
** Mem_cnnin2MODEL_COL_B: 512 flat devices **
XI0_0 VDD VDD BLB BLB_ WLA_0 WLB_0 VDD VSS Mem_cnnin2CCMB
XI0_1 VDD VDD BLB BLB_ WLA_1 WLB_1 VDD VSS Mem_cnnin2CCMB
XI0_10 VDD VDD BLB BLB_ WLA_10 WLB_10 VDD VSS Mem_cnnin2CCMB
XI0_11 VDD VDD BLB BLB_ WLA_11 WLB_11 VDD VSS Mem_cnnin2CCMB
XI0_12 VDD VDD BLB BLB_ WLA_12 WLB_12 VDD VSS Mem_cnnin2CCMB
XI0_13 VDD VDD BLB BLB_ WLA_13 WLB_13 VDD VSS Mem_cnnin2CCMB
XI0_14 VDD VDD BLB BLB_ WLA_14 WLB_14 VDD VSS Mem_cnnin2CCMB
XI0_15 VDD VDD BLB BLB_ WLA_15 WLB_15 VDD VSS Mem_cnnin2CCMB
XI0_16 VDD VDD BLB BLB_ WLA_16 WLB_16 VDD VSS Mem_cnnin2CCMB
XI0_17 VDD VDD BLB BLB_ WLA_17 WLB_17 VDD VSS Mem_cnnin2CCMB
XI0_18 VDD VDD BLB BLB_ WLA_18 WLB_18 VDD VSS Mem_cnnin2CCMB
XI0_19 VDD VDD BLB BLB_ WLA_19 WLB_19 VDD VSS Mem_cnnin2CCMB
XI0_2 VDD VDD BLB BLB_ WLA_2 WLB_2 VDD VSS Mem_cnnin2CCMB
XI0_20 VDD VDD BLB BLB_ WLA_20 WLB_20 VDD VSS Mem_cnnin2CCMB
XI0_21 VDD VDD BLB BLB_ WLA_21 WLB_21 VDD VSS Mem_cnnin2CCMB
XI0_22 VDD VDD BLB BLB_ WLA_22 WLB_22 VDD VSS Mem_cnnin2CCMB
XI0_23 VDD VDD BLB BLB_ WLA_23 WLB_23 VDD VSS Mem_cnnin2CCMB
XI0_24 VDD VDD BLB BLB_ WLA_24 WLB_24 VDD VSS Mem_cnnin2CCMB
XI0_25 VDD VDD BLB BLB_ WLA_25 WLB_25 VDD VSS Mem_cnnin2CCMB
XI0_26 VDD VDD BLB BLB_ WLA_26 WLB_26 VDD VSS Mem_cnnin2CCMB
XI0_27 VDD VDD BLB BLB_ WLA_27 WLB_27 VDD VSS Mem_cnnin2CCMB
XI0_28 VDD VDD BLB BLB_ WLA_28 WLB_28 VDD VSS Mem_cnnin2CCMB
XI0_29 VDD VDD BLB BLB_ WLA_29 WLB_29 VDD VSS Mem_cnnin2CCMB
XI0_3 VDD VDD BLB BLB_ WLA_3 WLB_3 VDD VSS Mem_cnnin2CCMB
XI0_30 VDD VDD BLB BLB_ WLA_30 WLB_30 VDD VSS Mem_cnnin2CCMB
XI0_31 VDD VDD BLB BLB_ WLA_31 WLB_31 VDD VSS Mem_cnnin2CCMB
XI0_33 VDD VDD BLB_ BLB WLA_32 WLB_32 VDD VSS Mem_cnnin2CCMB
XI0_34 VDD VDD BLB_ BLB WLA_33 WLB_33 VDD VSS Mem_cnnin2CCMB
XI0_35 VDD VDD BLB_ BLB WLA_34 WLB_34 VDD VSS Mem_cnnin2CCMB
XI0_36 VDD VDD BLB_ BLB WLA_35 WLB_35 VDD VSS Mem_cnnin2CCMB
XI0_37 VDD VDD BLB_ BLB WLA_36 WLB_36 VDD VSS Mem_cnnin2CCMB
XI0_38 VDD VDD BLB_ BLB WLA_37 WLB_37 VDD VSS Mem_cnnin2CCMB
XI0_39 VDD VDD BLB_ BLB WLA_38 WLB_38 VDD VSS Mem_cnnin2CCMB
XI0_4 VDD VDD BLB BLB_ WLA_4 WLB_4 VDD VSS Mem_cnnin2CCMB
XI0_40 VDD VDD BLB_ BLB WLA_39 WLB_39 VDD VSS Mem_cnnin2CCMB
XI0_41 VDD VDD BLB_ BLB WLA_40 WLB_40 VDD VSS Mem_cnnin2CCMB
XI0_42 VDD VDD BLB_ BLB WLA_41 WLB_41 VDD VSS Mem_cnnin2CCMB
XI0_43 VDD VDD BLB_ BLB WLA_42 WLB_42 VDD VSS Mem_cnnin2CCMB
XI0_44 VDD VDD BLB_ BLB WLA_43 WLB_43 VDD VSS Mem_cnnin2CCMB
XI0_45 VDD VDD BLB_ BLB WLA_44 WLB_44 VDD VSS Mem_cnnin2CCMB
XI0_46 VDD VDD BLB_ BLB WLA_45 WLB_45 VDD VSS Mem_cnnin2CCMB
XI0_47 VDD VDD BLB_ BLB WLA_46 WLB_46 VDD VSS Mem_cnnin2CCMB
XI0_48 VDD VDD BLB_ BLB WLA_47 WLB_47 VDD VSS Mem_cnnin2CCMB
XI0_49 VDD VDD BLB_ BLB WLA_48 WLB_48 VDD VSS Mem_cnnin2CCMB
XI0_5 VDD VDD BLB BLB_ WLA_5 WLB_5 VDD VSS Mem_cnnin2CCMB
XI0_50 VDD VDD BLB_ BLB WLA_49 WLB_49 VDD VSS Mem_cnnin2CCMB
XI0_51 VDD VDD BLB_ BLB WLA_50 WLB_50 VDD VSS Mem_cnnin2CCMB
XI0_52 VDD VDD BLB_ BLB WLA_51 WLB_51 VDD VSS Mem_cnnin2CCMB
XI0_53 VDD VDD BLB_ BLB WLA_52 WLB_52 VDD VSS Mem_cnnin2CCMB
XI0_54 VDD VDD BLB_ BLB WLA_53 WLB_53 VDD VSS Mem_cnnin2CCMB
XI0_55 VDD VDD BLB_ BLB WLA_54 WLB_54 VDD VSS Mem_cnnin2CCMB
XI0_56 VDD VDD BLB_ BLB WLA_55 WLB_55 VDD VSS Mem_cnnin2CCMB
XI0_57 VDD VDD BLB_ BLB WLA_56 WLB_56 VDD VSS Mem_cnnin2CCMB
XI0_58 VDD VDD BLB_ BLB WLA_57 WLB_57 VDD VSS Mem_cnnin2CCMB
XI0_59 VDD VDD BLB_ BLB WLA_58 WLB_58 VDD VSS Mem_cnnin2CCMB
XI0_6 VDD VDD BLB BLB_ WLA_6 WLB_6 VDD VSS Mem_cnnin2CCMB
XI0_60 VDD VDD BLB_ BLB WLA_59 WLB_59 VDD VSS Mem_cnnin2CCMB
XI0_61 VDD VDD BLB_ BLB WLA_60 WLB_60 VDD VSS Mem_cnnin2CCMB
XI0_62 VDD VDD BLB_ BLB WLA_61 WLB_61 VDD VSS Mem_cnnin2CCMB
XI0_63 VDD VDD BLB_ BLB WLA_62 WLB_62 VDD VSS Mem_cnnin2CCMB
XI0_64 VDD VDD BLB_ BLB WLA_63 WLB_63 VDD VSS Mem_cnnin2CCMB
XI0_7 VDD VDD BLB BLB_ WLA_7 WLB_7 VDD VSS Mem_cnnin2CCMB
XI0_8 VDD VDD BLB BLB_ WLA_8 WLB_8 VDD VSS Mem_cnnin2CCMB
XI0_9 VDD VDD BLB BLB_ WLA_9 WLB_9 VDD VSS Mem_cnnin2CCMB
.ENDS Mem_cnnin2MODEL_COL_B
****
.SUBCKT Mem_cnnin2HXP38X_A A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA
+  BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2HXP38X_A: 201 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38
.ENDS Mem_cnnin2HXP38X_A
****
.SUBCKT Mem_cnnin2X_PRE_DECODEA A0_0 A0_1 A1_0 A1_1 A2_0 A2_1 AGTPB AGTPT AY0A
+  AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB XP_0_0 XP_0_1 XP_1_0
+  XP_1_1 XP_2_0 XP_2_1 XP_3_0 XP_3_1 XP_4_0 XP_4_1 XP_5_0 XP_5_1 XP_6_0
+  XP_6_1 XP_7_0 XP_7_1 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
** Mem_cnnin2X_PRE_DECODEA: 402 flat devices **
XI0_0 A0_0 A1_0 A2_0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38X_A
XI1_0 A0_1 A1_1 A2_1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_1 XP_1_1 XP_2_1 XP_3_1 XP_4_1 XP_5_1 XP_6_1 XP_7_1 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS Mem_cnnin2HXP38X_A
.ENDS Mem_cnnin2X_PRE_DECODEA
****
.SUBCKT Mem_cnnin2HYP12XLX_A A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS
** Mem_cnnin2HYP12XLX_A: 95 flat devices **
XI0_0 A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS Mem_cnnin2HYP12XL
.ENDS Mem_cnnin2HYP12XLX_A
****
.SUBCKT Mem_cnnin2HYP12XRX_A A0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK
+  GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VDD VSS
** Mem_cnnin2HYP12XRX_A: 95 flat devices **
XI0_0 A0 AGTP AY0A AY0A AY0A_ AY0B AY0B_ AY0A_ BWENA BWENB CLK GSRCN GTPN
+  OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VDD VSS
+  Mem_cnnin2HYP12XR
.ENDS Mem_cnnin2HYP12XRX_A
****
.SUBCKT Mem_cnnin2Y_DECODEA A0_0 A0_1 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD
+  VSS
** Mem_cnnin2Y_DECODEA: 190 flat devices **
XI0_0 A0_0 AGTP AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS Mem_cnnin2HYP12XLX_A
XI1_0 A0_1 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK GSRCN GTPN OEIA_ OEIB_
+  RST WEIA WEIB YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS
+  VSS VSS VSS VSS VDD VSS Mem_cnnin2HYP12XRX_A
.ENDS Mem_cnnin2Y_DECODEA
****
.SUBCKT Mem_cnnin2HBFX_A CEN CLK GSRCN GTPA GTPB GTPN MBL RST STUBBWA STUBBWB
+  WEIA WEIB WEN VDD VSS
** Mem_cnnin2HBFX_A: 76 flat devices **
XI0_0 CEN CLK GSRCN GTPA GTPA GTPB GTPN MBL RST VSS STUBBWA STUBBWB VSS WEIA
+  WEIA WEIB WEN VDD VSS Mem_cnnin2HBF4
.ENDS Mem_cnnin2HBFX_A
****
.SUBCKT Mem_cnnin2WDX_0_A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_0_A: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_0_A
****
.SUBCKT Mem_cnnin2ROW_8A G0 G1 G1B GTP WLA0 WLA1 WLB0 WLB1 XP0F_0 XP0F_1
+  XP0F_2 XP0F_3 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_8A: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_0_A
.ENDS Mem_cnnin2ROW_8A
****
.SUBCKT Mem_cnnin2WDX_1_A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_1_A: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_1_A
****
.SUBCKT Mem_cnnin2ROW_FILLER1A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER1A: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_1_A
.ENDS Mem_cnnin2ROW_FILLER1A
****
.SUBCKT Mem_cnnin2WDX_2_A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_2_A: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_2_A
****
.SUBCKT Mem_cnnin2ROW_FILLER2A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER2A: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_2_A
.ENDS Mem_cnnin2ROW_FILLER2A
****
.SUBCKT Mem_cnnin2WDX_3_A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2WDX_3_A: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2WD
.ENDS Mem_cnnin2WDX_3_A
****
.SUBCKT Mem_cnnin2ROW_FILLER3A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0_0 XP0_1
+  XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS
** Mem_cnnin2ROW_FILLER3A: 30 flat devices **
XI4_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WDX_3_A
.ENDS Mem_cnnin2ROW_FILLER3A
****
.SUBCKT Mem_cnnin2HWDBX_A G0 G1 G2_W0 G2_W1 GTPA GTPB WLA0 WLA1 WLB0 WLB1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2HWDBX_A: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTPA GTPA GTPA GTPA GTPA GTPA GTPB WLA0 WLA1 WLA0 WLA1
+  WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2HWDB
.ENDS Mem_cnnin2HWDBX_A
****
.SUBCKT Mem_cnnin2HWDBX_A0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2HWDBX_A0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS Mem_cnnin2HWDBX_A
.ENDS Mem_cnnin2HWDBX_A0
****
.SUBCKT Mem_cnnin2ROW_BOTTOMA G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0F_0
+  XP0F_1 XP0F_2 XP0F_3 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_BOTTOMA: 30 flat devices **
XI4_0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS Mem_cnnin2HWDBX_A0
.ENDS Mem_cnnin2ROW_BOTTOMA
****
.SUBCKT Mem_cnnin2MWDX_A GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** Mem_cnnin2MWDX_A: 41 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS MWLA
+  MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2MWD
.ENDS Mem_cnnin2MWDX_A
****
.SUBCKT Mem_cnnin2ROW_TOPA G0F G1F GTP MBL MBL_ MWLA MWLB MWLD XP0F XP0_0
+  XP0_1 XP0_2 XP1F XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** Mem_cnnin2ROW_TOPA: 49 flat devices **
XI0_0 MWLA MWLB XP0_0 XP1_0 VDD VSS Mem_cnnin2FCMWDX
XI1_0 MWLA MWLB XP0_1 XP1_1 VDD VSS Mem_cnnin2FCMWDX
XI2_0 MWLA MWLB XP0_2 XP1_2 VDD VSS Mem_cnnin2FCMWDX
XI3_0 G0F G1F MWLA MWLB XP0F XP1F VDD VSS Mem_cnnin2FCMWD
XI4_0 GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2MWDX_A
.ENDS Mem_cnnin2ROW_TOPA
****
.SUBCKT Mem_cnnin2WORD_ROWSA G0 GTPA GTPB MBL MBL_ MWLA MWLB MWLD WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16 WLA0_17 WLA0_18 WLA0_19
+  WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25 WLA0_26 WLA0_27 WLA0_28
+  WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4 WLA1_5 WLA1_6
+  WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14 WLA1_15
+  WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22 WLA1_23 WLA1_24
+  WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31 WLB0_0 WLB0_1
+  WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9 WLB0_10 WLB0_11
+  WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18 WLB0_19 WLB0_20
+  WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27 WLB0_28 WLB0_29
+  WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5 WLB1_6 WLB1_7
+  WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15 WLB1_16
+  WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24 WLB1_25
+  WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS
** Mem_cnnin2WORD_ROWSA: 1009 flat devices **
XI0_0 G0 XP0_3 GTPA GTPB WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_BOTTOMA
XI0_1 G0 XP0_3 GTPA WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1A
XI0_10 G0 XP0_2 GTPA WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_11 G0 XP0_2 GTPA WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_12 G0 XP1_2 XP0_2 GTPA WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8A
XI0_13 G0 XP1_2 GTPA WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1A
XI0_14 G0 XP1_2 GTPA WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_15 G0 XP1_2 GTPA WLA0_15 WLA1_15 WLB0_15 WLB1_15 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_17 G0 XP0_1 XP1_2 GTPA WLA0_16 WLA1_16 WLB0_16 WLB1_16 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8A
XI0_18 G0 XP0_1 GTPA WLA0_17 WLA1_17 WLB0_17 WLB1_17 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1A
XI0_19 G0 XP0_1 GTPA WLA0_18 WLA1_18 WLB0_18 WLB1_18 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_2 G0 XP0_3 GTPA WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER2A
XI0_20 G0 XP0_1 GTPA WLA0_19 WLA1_19 WLB0_19 WLB1_19 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_21 G0 XP1_1 XP0_1 GTPA WLA0_20 WLA1_20 WLB0_20 WLB1_20 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8A
XI0_22 G0 XP1_1 GTPA WLA0_21 WLA1_21 WLB0_21 WLB1_21 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1A
XI0_23 G0 XP1_1 GTPA WLA0_22 WLA1_22 WLB0_22 WLB1_22 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_24 G0 XP1_1 GTPA WLA0_23 WLA1_23 WLB0_23 WLB1_23 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_25 G0 XP0_0 XP1_1 GTPA WLA0_24 WLA1_24 WLB0_24 WLB1_24 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8A
XI0_26 G0 XP0_0 GTPA WLA0_25 WLA1_25 WLB0_25 WLB1_25 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1A
XI0_27 G0 XP0_0 GTPA WLA0_26 WLA1_26 WLB0_26 WLB1_26 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_28 G0 XP0_0 GTPA WLA0_27 WLA1_27 WLB0_27 WLB1_27 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_29 G0 XP1_0 XP0_0 GTPA WLA0_28 WLA1_28 WLB0_28 WLB1_28 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2ROW_8A
XI0_3 G0 XP0_3 GTPA WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER3A
XI0_30 G0 XP1_0 GTPA WLA0_29 WLA1_29 WLB0_29 WLB1_29 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER1A
XI0_31 G0 XP1_0 GTPA WLA0_30 WLA1_30 WLB0_30 WLB1_30 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER2A
XI0_32 G0 XP1_0 GTPA WLA0_31 WLA1_31 WLB0_31 WLB1_31 XP0_3 XP0_0 XP0_1 XP0_2
+  XP1_3 XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_FILLER3A
XI0_33 G0 XP1_0 GTPA MBL MBL_ MWLA MWLB MWLD XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_TOPA
XI0_4 G0 XP1_3 XP0_3 GTPA WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_8A
XI0_5 G0 XP1_3 GTPA WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1A
XI0_6 G0 XP1_3 GTPA WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER2A
XI0_7 G0 XP1_3 GTPA WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER3A
XI0_8 G0 XP0_2 XP1_3 GTPA WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0_0 XP0_1 XP0_2 XP0_3
+  XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS Mem_cnnin2ROW_8A
XI0_9 G0 XP0_2 GTPA WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0_3 XP0_0 XP0_1 XP0_2 XP1_3
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
+  Mem_cnnin2ROW_FILLER1A
.ENDS Mem_cnnin2WORD_ROWSA
****
.SUBCKT Mem_cnnin2 QA[63] QA[62] QA[61] QA[60] QA[59] QA[58] QA[57] QA[56]
+  QA[55] QA[54] QA[53] QA[52] QA[51] QA[50] QA[49] QA[48] QA[47] QA[46]
+  QA[45] QA[44] QA[43] QA[42] QA[41] QA[40] QA[39] QA[38] QA[37] QA[36]
+  QA[35] QA[34] QA[33] QA[32] QA[31] QA[30] QA[29] QA[28] QA[27] QA[26]
+  QA[25] QA[24] QA[23] QA[22] QA[21] QA[20] QA[19] QA[18] QA[17] QA[16]
+  QA[15] QA[14] QA[13] QA[12] QA[11] QA[10] QA[9] QA[8] QA[7] QA[6] QA[5]
+  QA[4] QA[3] QA[2] QA[1] QA[0] QB[63] QB[62] QB[61] QB[60] QB[59] QB[58]
+  QB[57] QB[56] QB[55] QB[54] QB[53] QB[52] QB[51] QB[50] QB[49] QB[48]
+  QB[47] QB[46] QB[45] QB[44] QB[43] QB[42] QB[41] QB[40] QB[39] QB[38]
+  QB[37] QB[36] QB[35] QB[34] QB[33] QB[32] QB[31] QB[30] QB[29] QB[28]
+  QB[27] QB[26] QB[25] QB[24] QB[23] QB[22] QB[21] QB[20] QB[19] QB[18]
+  QB[17] QB[16] QB[15] QB[14] QB[13] QB[12] QB[11] QB[10] QB[9] QB[8] QB[7]
+  QB[6] QB[5] QB[4] QB[3] QB[2] QB[1] QB[0] CLKA CENA WENA AA[7] AA[6] AA[5]
+  AA[4] AA[3] AA[2] AA[1] AA[0] DA[63] DA[62] DA[61] DA[60] DA[59] DA[58]
+  DA[57] DA[56] DA[55] DA[54] DA[53] DA[52] DA[51] DA[50] DA[49] DA[48]
+  DA[47] DA[46] DA[45] DA[44] DA[43] DA[42] DA[41] DA[40] DA[39] DA[38]
+  DA[37] DA[36] DA[35] DA[34] DA[33] DA[32] DA[31] DA[30] DA[29] DA[28]
+  DA[27] DA[26] DA[25] DA[24] DA[23] DA[22] DA[21] DA[20] DA[19] DA[18]
+  DA[17] DA[16] DA[15] DA[14] DA[13] DA[12] DA[11] DA[10] DA[9] DA[8] DA[7]
+  DA[6] DA[5] DA[4] DA[3] DA[2] DA[1] DA[0] CLKB CENB WENB AB[7] AB[6] AB[5]
+  AB[4] AB[3] AB[2] AB[1] AB[0] DB[63] DB[62] DB[61] DB[60] DB[59] DB[58]
+  DB[57] DB[56] DB[55] DB[54] DB[53] DB[52] DB[51] DB[50] DB[49] DB[48]
+  DB[47] DB[46] DB[45] DB[44] DB[43] DB[42] DB[41] DB[40] DB[39] DB[38]
+  DB[37] DB[36] DB[35] DB[34] DB[33] DB[32] DB[31] DB[30] DB[29] DB[28]
+  DB[27] DB[26] DB[25] DB[24] DB[23] DB[22] DB[21] DB[20] DB[19] DB[18]
+  DB[17] DB[16] DB[15] DB[14] DB[13] DB[12] DB[11] DB[10] DB[9] DB[8] DB[7]
+  DB[6] DB[5] DB[4] DB[3] DB[2] DB[1] DB[0] VDD VSS
** Mem_cnnin2: 167778 flat devices **
XI0_0 A0A A0A_ A0B A0B_ GTPA_2 GTPA_2 GTPA_2 GTPB_2 GTPB_2 GTPB_2 VSS VSS
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS
+  YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VDD VSS Mem_cnnin2RIGHT_CAP
XI10_2 A0A A0A_ A0B A0B_ CLKA GSRCN GTPA_2 GTPB_2 GTPN MBL MBLA_ VDD VDD
+  YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS
+  VDD VSS Mem_cnnin2FLCIOX_A
XI10_4 MBLA_ MBL MWLD MWLBD MWLBD MWLD WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2MODEL_COL_A
XI11_0 A0A A0A_ A0B A0B_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8
+  BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19
+  BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29
+  BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39
+  BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49
+  BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59
+  BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69
+  BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79
+  BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87 BLA_88 BLA_89
+  BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97 BLA_98 BLA_99
+  BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106 BLA_107 BLA_108
+  BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115 BLA_116 BLA_117
+  BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124 BLA_125 BLA_126
+  BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8
+  BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15 BLA__16 BLA__17
+  BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24 BLA__25 BLA__26
+  BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33 BLA__34 BLA__35
+  BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43 BLA__44
+  BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51 BLA__52 BLA__53
+  BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60 BLA__61 BLA__62
+  BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69 BLA__70 BLA__71
+  BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78 BLA__79 BLA__80
+  BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87 BLA__88 BLA__89
+  BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96 BLA__97 BLA__98
+  BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104 BLA__105 BLA__106
+  BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112 BLA__113 BLA__114
+  BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120 BLA__121 BLA__122
+  BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4
+  BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15
+  BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25
+  BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35
+  BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45
+  BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55
+  BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65
+  BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73 BLB_74 BLB_75
+  BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83 BLB_84 BLB_85
+  BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93 BLB_94 BLB_95
+  BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103 BLB_104 BLB_105
+  BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112 BLB_113 BLB_114
+  BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121 BLB_122 BLB_123
+  BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5
+  BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15
+  BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24
+  BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33
+  BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42
+  BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51
+  BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60
+  BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69
+  BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76 BLB__77 BLB__78
+  BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85 BLB__86 BLB__87
+  BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94 BLB__95 BLB__96
+  BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103 BLB__104
+  BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111 BLB__112
+  BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119 BLB__120
+  BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127 DA[32]
+  DB[32] DB[33] DA[33] DA[34] DB[34] DB[35] DA[35] DA[36] DB[36] DB[37]
+  DA[37] DA[38] DB[38] DB[39] DA[39] DA[40] DB[40] DB[41] DA[41] DA[42]
+  DB[42] DB[43] DA[43] DA[44] DB[44] DB[45] DA[45] DA[46] DB[46] DB[47]
+  DA[47] DA[48] DB[48] DB[49] DA[49] DA[50] DB[50] DB[51] DA[51] DA[52]
+  DB[52] DB[53] DA[53] DA[54] DB[54] DB[55] DA[55] DA[56] DB[56] DB[57]
+  DA[57] DA[58] DB[58] DB[59] DA[59] DA[60] DB[60] DB[61] DA[61] DA[62]
+  DB[62] DB[63] DA[63] GTPA_2 GTPA_2 GTPA_2 GTPB_2 GTPB_2 GTPB_2 VSS VSS
+  QA[32] QB[32] QB[33] QA[33] QA[34] QB[34] QB[35] QA[35] QA[36] QB[36]
+  QB[37] QA[37] QA[38] QB[38] QB[39] QA[39] QA[40] QB[40] QB[41] QA[41]
+  QA[42] QB[42] QB[43] QA[43] QA[44] QB[44] QB[45] QA[45] QA[46] QB[46]
+  QB[47] QA[47] QA[48] QB[48] QB[49] QA[49] QA[50] QB[50] QB[51] QA[51]
+  QA[52] QB[52] QB[53] QA[53] QA[54] QB[54] QB[55] QA[55] QA[56] QB[56]
+  QB[57] QA[57] QA[58] QB[58] QB[59] QA[59] QA[60] QB[60] QB[61] QA[61]
+  QA[62] QB[62] QB[63] QA[63] VSS STUBDRA_1 VSS STUBDRA__1 VSS STUBDRB_1 VSS
+  STUBDRB__1 VSS STUBDWA_1 VSS STUBDWA__1 VSS STUBDWB_1 VSS STUBDWB__1
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS
+  YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VDD VSS Mem_cnnin2WING_32_RIGHT
XI11_5 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19 BLA_20
+  BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29 BLA_30
+  BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40
+  BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49 BLA_50
+  BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59 BLA_60
+  BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70
+  BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79 BLA_80
+  BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87 BLA_88 BLA_89 BLA_90
+  BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97 BLA_98 BLA_99 BLA_100
+  BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106 BLA_107 BLA_108 BLA_109
+  BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115 BLA_116 BLA_117 BLA_118
+  BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124 BLA_125 BLA_126 BLA_127
+  BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8 BLA__9
+  BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15 BLA__16 BLA__17 BLA__18
+  BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24 BLA__25 BLA__26 BLA__27
+  BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33 BLA__34 BLA__35 BLA__36
+  BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43 BLA__44 BLA__45
+  BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51 BLA__52 BLA__53 BLA__54
+  BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60 BLA__61 BLA__62 BLA__63
+  BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69 BLA__70 BLA__71 BLA__72
+  BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78 BLA__79 BLA__80 BLA__81
+  BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87 BLA__88 BLA__89 BLA__90
+  BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96 BLA__97 BLA__98 BLA__99
+  BLA__100 BLA__101 BLA__102 BLA__103 BLA__104 BLA__105 BLA__106 BLA__107
+  BLA__108 BLA__109 BLA__110 BLA__111 BLA__112 BLA__113 BLA__114 BLA__115
+  BLA__116 BLA__117 BLA__118 BLA__119 BLA__120 BLA__121 BLA__122 BLA__123
+  BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5
+  BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB_16
+  BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25 BLB_26
+  BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36
+  BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46
+  BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55 BLB_56
+  BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65 BLB_66
+  BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73 BLB_74 BLB_75 BLB_76
+  BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83 BLB_84 BLB_85 BLB_86
+  BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93 BLB_94 BLB_95 BLB_96
+  BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103 BLB_104 BLB_105
+  BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112 BLB_113 BLB_114
+  BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121 BLB_122 BLB_123
+  BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5
+  BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15
+  BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24
+  BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33
+  BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42
+  BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51
+  BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60
+  BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69
+  BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76 BLB__77 BLB__78
+  BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85 BLB__86 BLB__87
+  BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94 BLB__95 BLB__96
+  BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103 BLB__104
+  BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111 BLB__112
+  BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119 BLB__120
+  BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127 VSS MWLD VSS
+  MWLBD VDD VSS Mem_cnnin2MODEL_ROW_32
XI12_0 A0A A0A_ A0B A0B_ GTPA_2 GTPA_2 GTPA_2 GTPB_2 GTPB_2 GTPB_2 VSS VSS
+  STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS
+  YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VDD VSS Mem_cnnin2RIGHT_CAP
XI1_0 A0A A0A_ A0B A0B_ BLA_0_1688 BLA_1_1674 BLA_2_1672 BLA_3_1658 BLA_4_1656
+  BLA_5_1642 BLA_6_1640 BLA_7_1626 BLA_8_1624 BLA_9_1610 BLA_10_1608
+  BLA_11_1594 BLA_12_1592 BLA_13_1578 BLA_14_1576 BLA_15_1562 BLA_16_1560
+  BLA_17_1546 BLA_18_1544 BLA_19_1530 BLA_20_1528 BLA_21_1514 BLA_22_1512
+  BLA_23_1498 BLA_24_1496 BLA_25_1482 BLA_26_1480 BLA_27_1466 BLA_28_1464
+  BLA_29_1450 BLA_30_1448 BLA_31_1434 BLA_32_1432 BLA_33_1418 BLA_34_1416
+  BLA_35_1402 BLA_36_1400 BLA_37_1386 BLA_38_1384 BLA_39_1370 BLA_40_1368
+  BLA_41_1354 BLA_42_1352 BLA_43_1338 BLA_44_1336 BLA_45_1322 BLA_46_1320
+  BLA_47_1306 BLA_48_1304 BLA_49_1290 BLA_50_1288 BLA_51_1274 BLA_52_1272
+  BLA_53_1258 BLA_54_1256 BLA_55_1242 BLA_56_1240 BLA_57_1226 BLA_58_1224
+  BLA_59_1210 BLA_60_1208 BLA_61_1194 BLA_62_1192 BLA_63_1178 BLA_64_1176
+  BLA_65_1162 BLA_66_1160 BLA_67_1146 BLA_68_1144 BLA_69_1130 BLA_70_1128
+  BLA_71_1114 BLA_72_1112 BLA_73_1098 BLA_74_1096 BLA_75_1082 BLA_76_1080
+  BLA_77_1066 BLA_78_1064 BLA_79_1050 BLA_80_1048 BLA_81_1034 BLA_82_1032
+  BLA_83_1018 BLA_84_1016 BLA_85_1002 BLA_86_1000 BLA_87_986 BLA_88_984
+  BLA_89_970 BLA_90_968 BLA_91_954 BLA_92_952 BLA_93_938 BLA_94_936
+  BLA_95_922 BLA_96_920 BLA_97_906 BLA_98_904 BLA_99_890 BLA_100_888
+  BLA_101_874 BLA_102_872 BLA_103_858 BLA_104_856 BLA_105_842 BLA_106_840
+  BLA_107_826 BLA_108_824 BLA_109_810 BLA_110_808 BLA_111_794 BLA_112_792
+  BLA_113_778 BLA_114_776 BLA_115_762 BLA_116_760 BLA_117_746 BLA_118_744
+  BLA_119_730 BLA_120_728 BLA_121_714 BLA_122_712 BLA_123_698 BLA_124_696
+  BLA_125_682 BLA_126_680 BLA_127_666 BLA__0_1682 BLA__1_1680 BLA__2_1666
+  BLA__3_1664 BLA__4_1650 BLA__5_1648 BLA__6_1634 BLA__7_1632 BLA__8_1618
+  BLA__9_1616 BLA__10_1602 BLA__11_1600 BLA__12_1586 BLA__13_1584
+  BLA__14_1570 BLA__15_1568 BLA__16_1554 BLA__17_1552 BLA__18_1538
+  BLA__19_1536 BLA__20_1522 BLA__21_1520 BLA__22_1506 BLA__23_1504
+  BLA__24_1490 BLA__25_1488 BLA__26_1474 BLA__27_1472 BLA__28_1458
+  BLA__29_1456 BLA__30_1442 BLA__31_1440 BLA__32_1426 BLA__33_1424
+  BLA__34_1410 BLA__35_1408 BLA__36_1394 BLA__37_1392 BLA__38_1378
+  BLA__39_1376 BLA__40_1362 BLA__41_1360 BLA__42_1346 BLA__43_1344
+  BLA__44_1330 BLA__45_1328 BLA__46_1314 BLA__47_1312 BLA__48_1298
+  BLA__49_1296 BLA__50_1282 BLA__51_1280 BLA__52_1266 BLA__53_1264
+  BLA__54_1250 BLA__55_1248 BLA__56_1234 BLA__57_1232 BLA__58_1218
+  BLA__59_1216 BLA__60_1202 BLA__61_1200 BLA__62_1186 BLA__63_1184
+  BLA__64_1170 BLA__65_1168 BLA__66_1154 BLA__67_1152 BLA__68_1138
+  BLA__69_1136 BLA__70_1122 BLA__71_1120 BLA__72_1106 BLA__73_1104
+  BLA__74_1090 BLA__75_1088 BLA__76_1074 BLA__77_1072 BLA__78_1058
+  BLA__79_1056 BLA__80_1042 BLA__81_1040 BLA__82_1026 BLA__83_1024
+  BLA__84_1010 BLA__85_1008 BLA__86_994 BLA__87_992 BLA__88_978 BLA__89_976
+  BLA__90_962 BLA__91_960 BLA__92_946 BLA__93_944 BLA__94_930 BLA__95_928
+  BLA__96_914 BLA__97_912 BLA__98_898 BLA__99_896 BLA__100_882 BLA__101_880
+  BLA__102_866 BLA__103_864 BLA__104_850 BLA__105_848 BLA__106_834
+  BLA__107_832 BLA__108_818 BLA__109_816 BLA__110_802 BLA__111_800
+  BLA__112_786 BLA__113_784 BLA__114_770 BLA__115_768 BLA__116_754
+  BLA__117_752 BLA__118_738 BLA__119_736 BLA__120_722 BLA__121_720
+  BLA__122_706 BLA__123_704 BLA__124_690 BLA__125_688 BLA__126_674
+  BLA__127_672 BLB_0_1686 BLB_1_1676 BLB_2_1670 BLB_3_1660 BLB_4_1654
+  BLB_5_1644 BLB_6_1638 BLB_7_1628 BLB_8_1622 BLB_9_1612 BLB_10_1606
+  BLB_11_1596 BLB_12_1590 BLB_13_1580 BLB_14_1574 BLB_15_1564 BLB_16_1558
+  BLB_17_1548 BLB_18_1542 BLB_19_1532 BLB_20_1526 BLB_21_1516 BLB_22_1510
+  BLB_23_1500 BLB_24_1494 BLB_25_1484 BLB_26_1478 BLB_27_1468 BLB_28_1462
+  BLB_29_1452 BLB_30_1446 BLB_31_1436 BLB_32_1430 BLB_33_1420 BLB_34_1414
+  BLB_35_1404 BLB_36_1398 BLB_37_1388 BLB_38_1382 BLB_39_1372 BLB_40_1366
+  BLB_41_1356 BLB_42_1350 BLB_43_1340 BLB_44_1334 BLB_45_1324 BLB_46_1318
+  BLB_47_1308 BLB_48_1302 BLB_49_1292 BLB_50_1286 BLB_51_1276 BLB_52_1270
+  BLB_53_1260 BLB_54_1254 BLB_55_1244 BLB_56_1238 BLB_57_1228 BLB_58_1222
+  BLB_59_1212 BLB_60_1206 BLB_61_1196 BLB_62_1190 BLB_63_1180 BLB_64_1174
+  BLB_65_1164 BLB_66_1158 BLB_67_1148 BLB_68_1142 BLB_69_1132 BLB_70_1126
+  BLB_71_1116 BLB_72_1110 BLB_73_1100 BLB_74_1094 BLB_75_1084 BLB_76_1078
+  BLB_77_1068 BLB_78_1062 BLB_79_1052 BLB_80_1046 BLB_81_1036 BLB_82_1030
+  BLB_83_1020 BLB_84_1014 BLB_85_1004 BLB_86_998 BLB_87_988 BLB_88_982
+  BLB_89_972 BLB_90_966 BLB_91_956 BLB_92_950 BLB_93_940 BLB_94_934
+  BLB_95_924 BLB_96_918 BLB_97_908 BLB_98_902 BLB_99_892 BLB_100_886
+  BLB_101_876 BLB_102_870 BLB_103_860 BLB_104_854 BLB_105_844 BLB_106_838
+  BLB_107_828 BLB_108_822 BLB_109_812 BLB_110_806 BLB_111_796 BLB_112_790
+  BLB_113_780 BLB_114_774 BLB_115_764 BLB_116_758 BLB_117_748 BLB_118_742
+  BLB_119_732 BLB_120_726 BLB_121_716 BLB_122_710 BLB_123_700 BLB_124_694
+  BLB_125_684 BLB_126_678 BLB_127_668 BLB__0_1684 BLB__1_1678 BLB__2_1668
+  BLB__3_1662 BLB__4_1652 BLB__5_1646 BLB__6_1636 BLB__7_1630 BLB__8_1620
+  BLB__9_1614 BLB__10_1604 BLB__11_1598 BLB__12_1588 BLB__13_1582
+  BLB__14_1572 BLB__15_1566 BLB__16_1556 BLB__17_1550 BLB__18_1540
+  BLB__19_1534 BLB__20_1524 BLB__21_1518 BLB__22_1508 BLB__23_1502
+  BLB__24_1492 BLB__25_1486 BLB__26_1476 BLB__27_1470 BLB__28_1460
+  BLB__29_1454 BLB__30_1444 BLB__31_1438 BLB__32_1428 BLB__33_1422
+  BLB__34_1412 BLB__35_1406 BLB__36_1396 BLB__37_1390 BLB__38_1380
+  BLB__39_1374 BLB__40_1364 BLB__41_1358 BLB__42_1348 BLB__43_1342
+  BLB__44_1332 BLB__45_1326 BLB__46_1316 BLB__47_1310 BLB__48_1300
+  BLB__49_1294 BLB__50_1284 BLB__51_1278 BLB__52_1268 BLB__53_1262
+  BLB__54_1252 BLB__55_1246 BLB__56_1236 BLB__57_1230 BLB__58_1220
+  BLB__59_1214 BLB__60_1204 BLB__61_1198 BLB__62_1188 BLB__63_1182
+  BLB__64_1172 BLB__65_1166 BLB__66_1156 BLB__67_1150 BLB__68_1140
+  BLB__69_1134 BLB__70_1124 BLB__71_1118 BLB__72_1108 BLB__73_1102
+  BLB__74_1092 BLB__75_1086 BLB__76_1076 BLB__77_1070 BLB__78_1060
+  BLB__79_1054 BLB__80_1044 BLB__81_1038 BLB__82_1028 BLB__83_1022
+  BLB__84_1012 BLB__85_1006 BLB__86_996 BLB__87_990 BLB__88_980 BLB__89_974
+  BLB__90_964 BLB__91_958 BLB__92_948 BLB__93_942 BLB__94_932 BLB__95_926
+  BLB__96_916 BLB__97_910 BLB__98_900 BLB__99_894 BLB__100_884 BLB__101_878
+  BLB__102_868 BLB__103_862 BLB__104_852 BLB__105_846 BLB__106_836
+  BLB__107_830 BLB__108_820 BLB__109_814 BLB__110_804 BLB__111_798
+  BLB__112_788 BLB__113_782 BLB__114_772 BLB__115_766 BLB__116_756
+  BLB__117_750 BLB__118_740 BLB__119_734 BLB__120_724 BLB__121_718
+  BLB__122_708 BLB__123_702 BLB__124_692 BLB__125_686 BLB__126_676
+  BLB__127_670 DA[31] DB[31] DB[30] DA[30] DA[29] DB[29] DB[28] DA[28] DA[27]
+  DB[27] DB[26] DA[26] DA[25] DB[25] DB[24] DA[24] DA[23] DB[23] DB[22]
+  DA[22] DA[21] DB[21] DB[20] DA[20] DA[19] DB[19] DB[18] DA[18] DA[17]
+  DB[17] DB[16] DA[16] DA[15] DB[15] DB[14] DA[14] DA[13] DB[13] DB[12]
+  DA[12] DA[11] DB[11] DB[10] DA[10] DA[9] DB[9] DB[8] DA[8] DA[7] DB[7]
+  DB[6] DA[6] DA[5] DB[5] DB[4] DA[4] DA[3] DB[3] DB[2] DA[2] DA[1] DB[1]
+  DB[0] DA[0] GTPA_2 GTPA_2 GTPA_2 GTPB_2 GTPB_2 GTPB_2 VSS VSS QA[31] QB[31]
+  QB[30] QA[30] QA[29] QB[29] QB[28] QA[28] QA[27] QB[27] QB[26] QA[26]
+  QA[25] QB[25] QB[24] QA[24] QA[23] QB[23] QB[22] QA[22] QA[21] QB[21]
+  QB[20] QA[20] QA[19] QB[19] QB[18] QA[18] QA[17] QB[17] QB[16] QA[16]
+  QA[15] QB[15] QB[14] QA[14] QA[13] QB[13] QB[12] QA[12] QA[11] QB[11]
+  QB[10] QA[10] QA[9] QB[9] QB[8] QA[8] QA[7] QB[7] QB[6] QA[6] QA[5] QB[5]
+  QB[4] QA[4] QA[3] QB[3] QB[2] QA[2] QA[1] QB[1] QB[0] QA[0] VSS
+  STUBDRA_1_1692 VSS STUBDRA__1_1690 VSS STUBDRB_1_1696 VSS STUBDRB__1_1694
+  VSS STUBDWA_1_1698 VSS STUBDWA__1_1700 VSS STUBDWB_1_1702 VSS
+  STUBDWB__1_1704 STUBWEA STUBWEB WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 YPA0_0 YPA0_1 VSS
+  VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VDD VSS
+  Mem_cnnin2WING_32_LEFT
XI1_5 BLA_0_1688 BLA_1_1674 BLA_2_1672 BLA_3_1658 BLA_4_1656 BLA_5_1642
+  BLA_6_1640 BLA_7_1626 BLA_8_1624 BLA_9_1610 BLA_10_1608 BLA_11_1594
+  BLA_12_1592 BLA_13_1578 BLA_14_1576 BLA_15_1562 BLA_16_1560 BLA_17_1546
+  BLA_18_1544 BLA_19_1530 BLA_20_1528 BLA_21_1514 BLA_22_1512 BLA_23_1498
+  BLA_24_1496 BLA_25_1482 BLA_26_1480 BLA_27_1466 BLA_28_1464 BLA_29_1450
+  BLA_30_1448 BLA_31_1434 BLA_32_1432 BLA_33_1418 BLA_34_1416 BLA_35_1402
+  BLA_36_1400 BLA_37_1386 BLA_38_1384 BLA_39_1370 BLA_40_1368 BLA_41_1354
+  BLA_42_1352 BLA_43_1338 BLA_44_1336 BLA_45_1322 BLA_46_1320 BLA_47_1306
+  BLA_48_1304 BLA_49_1290 BLA_50_1288 BLA_51_1274 BLA_52_1272 BLA_53_1258
+  BLA_54_1256 BLA_55_1242 BLA_56_1240 BLA_57_1226 BLA_58_1224 BLA_59_1210
+  BLA_60_1208 BLA_61_1194 BLA_62_1192 BLA_63_1178 BLA_64_1176 BLA_65_1162
+  BLA_66_1160 BLA_67_1146 BLA_68_1144 BLA_69_1130 BLA_70_1128 BLA_71_1114
+  BLA_72_1112 BLA_73_1098 BLA_74_1096 BLA_75_1082 BLA_76_1080 BLA_77_1066
+  BLA_78_1064 BLA_79_1050 BLA_80_1048 BLA_81_1034 BLA_82_1032 BLA_83_1018
+  BLA_84_1016 BLA_85_1002 BLA_86_1000 BLA_87_986 BLA_88_984 BLA_89_970
+  BLA_90_968 BLA_91_954 BLA_92_952 BLA_93_938 BLA_94_936 BLA_95_922
+  BLA_96_920 BLA_97_906 BLA_98_904 BLA_99_890 BLA_100_888 BLA_101_874
+  BLA_102_872 BLA_103_858 BLA_104_856 BLA_105_842 BLA_106_840 BLA_107_826
+  BLA_108_824 BLA_109_810 BLA_110_808 BLA_111_794 BLA_112_792 BLA_113_778
+  BLA_114_776 BLA_115_762 BLA_116_760 BLA_117_746 BLA_118_744 BLA_119_730
+  BLA_120_728 BLA_121_714 BLA_122_712 BLA_123_698 BLA_124_696 BLA_125_682
+  BLA_126_680 BLA_127_666 BLA__0_1682 BLA__1_1680 BLA__2_1666 BLA__3_1664
+  BLA__4_1650 BLA__5_1648 BLA__6_1634 BLA__7_1632 BLA__8_1618 BLA__9_1616
+  BLA__10_1602 BLA__11_1600 BLA__12_1586 BLA__13_1584 BLA__14_1570
+  BLA__15_1568 BLA__16_1554 BLA__17_1552 BLA__18_1538 BLA__19_1536
+  BLA__20_1522 BLA__21_1520 BLA__22_1506 BLA__23_1504 BLA__24_1490
+  BLA__25_1488 BLA__26_1474 BLA__27_1472 BLA__28_1458 BLA__29_1456
+  BLA__30_1442 BLA__31_1440 BLA__32_1426 BLA__33_1424 BLA__34_1410
+  BLA__35_1408 BLA__36_1394 BLA__37_1392 BLA__38_1378 BLA__39_1376
+  BLA__40_1362 BLA__41_1360 BLA__42_1346 BLA__43_1344 BLA__44_1330
+  BLA__45_1328 BLA__46_1314 BLA__47_1312 BLA__48_1298 BLA__49_1296
+  BLA__50_1282 BLA__51_1280 BLA__52_1266 BLA__53_1264 BLA__54_1250
+  BLA__55_1248 BLA__56_1234 BLA__57_1232 BLA__58_1218 BLA__59_1216
+  BLA__60_1202 BLA__61_1200 BLA__62_1186 BLA__63_1184 BLA__64_1170
+  BLA__65_1168 BLA__66_1154 BLA__67_1152 BLA__68_1138 BLA__69_1136
+  BLA__70_1122 BLA__71_1120 BLA__72_1106 BLA__73_1104 BLA__74_1090
+  BLA__75_1088 BLA__76_1074 BLA__77_1072 BLA__78_1058 BLA__79_1056
+  BLA__80_1042 BLA__81_1040 BLA__82_1026 BLA__83_1024 BLA__84_1010
+  BLA__85_1008 BLA__86_994 BLA__87_992 BLA__88_978 BLA__89_976 BLA__90_962
+  BLA__91_960 BLA__92_946 BLA__93_944 BLA__94_930 BLA__95_928 BLA__96_914
+  BLA__97_912 BLA__98_898 BLA__99_896 BLA__100_882 BLA__101_880 BLA__102_866
+  BLA__103_864 BLA__104_850 BLA__105_848 BLA__106_834 BLA__107_832
+  BLA__108_818 BLA__109_816 BLA__110_802 BLA__111_800 BLA__112_786
+  BLA__113_784 BLA__114_770 BLA__115_768 BLA__116_754 BLA__117_752
+  BLA__118_738 BLA__119_736 BLA__120_722 BLA__121_720 BLA__122_706
+  BLA__123_704 BLA__124_690 BLA__125_688 BLA__126_674 BLA__127_672 BLB_0_1686
+  BLB_1_1676 BLB_2_1670 BLB_3_1660 BLB_4_1654 BLB_5_1644 BLB_6_1638
+  BLB_7_1628 BLB_8_1622 BLB_9_1612 BLB_10_1606 BLB_11_1596 BLB_12_1590
+  BLB_13_1580 BLB_14_1574 BLB_15_1564 BLB_16_1558 BLB_17_1548 BLB_18_1542
+  BLB_19_1532 BLB_20_1526 BLB_21_1516 BLB_22_1510 BLB_23_1500 BLB_24_1494
+  BLB_25_1484 BLB_26_1478 BLB_27_1468 BLB_28_1462 BLB_29_1452 BLB_30_1446
+  BLB_31_1436 BLB_32_1430 BLB_33_1420 BLB_34_1414 BLB_35_1404 BLB_36_1398
+  BLB_37_1388 BLB_38_1382 BLB_39_1372 BLB_40_1366 BLB_41_1356 BLB_42_1350
+  BLB_43_1340 BLB_44_1334 BLB_45_1324 BLB_46_1318 BLB_47_1308 BLB_48_1302
+  BLB_49_1292 BLB_50_1286 BLB_51_1276 BLB_52_1270 BLB_53_1260 BLB_54_1254
+  BLB_55_1244 BLB_56_1238 BLB_57_1228 BLB_58_1222 BLB_59_1212 BLB_60_1206
+  BLB_61_1196 BLB_62_1190 BLB_63_1180 BLB_64_1174 BLB_65_1164 BLB_66_1158
+  BLB_67_1148 BLB_68_1142 BLB_69_1132 BLB_70_1126 BLB_71_1116 BLB_72_1110
+  BLB_73_1100 BLB_74_1094 BLB_75_1084 BLB_76_1078 BLB_77_1068 BLB_78_1062
+  BLB_79_1052 BLB_80_1046 BLB_81_1036 BLB_82_1030 BLB_83_1020 BLB_84_1014
+  BLB_85_1004 BLB_86_998 BLB_87_988 BLB_88_982 BLB_89_972 BLB_90_966
+  BLB_91_956 BLB_92_950 BLB_93_940 BLB_94_934 BLB_95_924 BLB_96_918
+  BLB_97_908 BLB_98_902 BLB_99_892 BLB_100_886 BLB_101_876 BLB_102_870
+  BLB_103_860 BLB_104_854 BLB_105_844 BLB_106_838 BLB_107_828 BLB_108_822
+  BLB_109_812 BLB_110_806 BLB_111_796 BLB_112_790 BLB_113_780 BLB_114_774
+  BLB_115_764 BLB_116_758 BLB_117_748 BLB_118_742 BLB_119_732 BLB_120_726
+  BLB_121_716 BLB_122_710 BLB_123_700 BLB_124_694 BLB_125_684 BLB_126_678
+  BLB_127_668 BLB__0_1684 BLB__1_1678 BLB__2_1668 BLB__3_1662 BLB__4_1652
+  BLB__5_1646 BLB__6_1636 BLB__7_1630 BLB__8_1620 BLB__9_1614 BLB__10_1604
+  BLB__11_1598 BLB__12_1588 BLB__13_1582 BLB__14_1572 BLB__15_1566
+  BLB__16_1556 BLB__17_1550 BLB__18_1540 BLB__19_1534 BLB__20_1524
+  BLB__21_1518 BLB__22_1508 BLB__23_1502 BLB__24_1492 BLB__25_1486
+  BLB__26_1476 BLB__27_1470 BLB__28_1460 BLB__29_1454 BLB__30_1444
+  BLB__31_1438 BLB__32_1428 BLB__33_1422 BLB__34_1412 BLB__35_1406
+  BLB__36_1396 BLB__37_1390 BLB__38_1380 BLB__39_1374 BLB__40_1364
+  BLB__41_1358 BLB__42_1348 BLB__43_1342 BLB__44_1332 BLB__45_1326
+  BLB__46_1316 BLB__47_1310 BLB__48_1300 BLB__49_1294 BLB__50_1284
+  BLB__51_1278 BLB__52_1268 BLB__53_1262 BLB__54_1252 BLB__55_1246
+  BLB__56_1236 BLB__57_1230 BLB__58_1220 BLB__59_1214 BLB__60_1204
+  BLB__61_1198 BLB__62_1188 BLB__63_1182 BLB__64_1172 BLB__65_1166
+  BLB__66_1156 BLB__67_1150 BLB__68_1140 BLB__69_1134 BLB__70_1124
+  BLB__71_1118 BLB__72_1108 BLB__73_1102 BLB__74_1092 BLB__75_1086
+  BLB__76_1076 BLB__77_1070 BLB__78_1060 BLB__79_1054 BLB__80_1044
+  BLB__81_1038 BLB__82_1028 BLB__83_1022 BLB__84_1012 BLB__85_1006
+  BLB__86_996 BLB__87_990 BLB__88_980 BLB__89_974 BLB__90_964 BLB__91_958
+  BLB__92_948 BLB__93_942 BLB__94_932 BLB__95_926 BLB__96_916 BLB__97_910
+  BLB__98_900 BLB__99_894 BLB__100_884 BLB__101_878 BLB__102_868 BLB__103_862
+  BLB__104_852 BLB__105_846 BLB__106_836 BLB__107_830 BLB__108_820
+  BLB__109_814 BLB__110_804 BLB__111_798 BLB__112_788 BLB__113_782
+  BLB__114_772 BLB__115_766 BLB__116_756 BLB__117_750 BLB__118_740
+  BLB__119_734 BLB__120_724 BLB__121_718 BLB__122_708 BLB__123_702
+  BLB__124_692 BLB__125_686 BLB__126_676 BLB__127_670 VSS MWLD VSS MWLBD VDD
+  VSS Mem_cnnin2MODEL_ROW_32
XI2_0 CENB CLKB GSRCN_1710 GTPA_2 GTPB_2 GTPN_1708 MBL_1706 RST VSS VSS
+  STUBWEA STUBWEB WENB VDD VSS Mem_cnnin2HBFX_B
XI2_2 A0A A0A_ A0B A0B_ CLKB GSRCN_1710 GTPA_2 GTPB_2 GTPN_1708 MBL_1706 VDD
+  VDD MBLB_ YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VDD VSS Mem_cnnin2FLCIOX_B
XI2_4 MBLB_ MBL_1706 MWLD MWLD MWLBD MWLBD WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36
+  WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46
+  WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56
+  WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3
+  WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14
+  WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24
+  WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34
+  WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44
+  WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54
+  WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDD VSS
+  Mem_cnnin2MODEL_COL_B
XI3_2 A0A A0A_ A0B A0B_ AGTP CLKB GSRCN_1710 GTPN_1708 GTPB_2 GTPB_2 GTPB_2
+  GTPB_2 RST YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VDD VSS Mem_cnnin2CLK_DRVS
XI3_3 VDD GTPA_2 GTPB_2 MBL_1706 MBLB_ MWLD MWLBD MWLBD WLA_0 WLA_3 WLA_4
+  WLA_7 WLA_8 WLA_11 WLA_12 WLA_15 WLA_16 WLA_19 WLA_20 WLA_23 WLA_24 WLA_27
+  WLA_28 WLA_31 WLA_32 WLA_35 WLA_36 WLA_39 WLA_40 WLA_43 WLA_44 WLA_47
+  WLA_48 WLA_51 WLA_52 WLA_55 WLA_56 WLA_59 WLA_60 WLA_63 WLA_1 WLA_2 WLA_5
+  WLA_6 WLA_9 WLA_10 WLA_13 WLA_14 WLA_17 WLA_18 WLA_21 WLA_22 WLA_25 WLA_26
+  WLA_29 WLA_30 WLA_33 WLA_34 WLA_37 WLA_38 WLA_41 WLA_42 WLA_45 WLA_46
+  WLA_49 WLA_50 WLA_53 WLA_54 WLA_57 WLA_58 WLA_61 WLA_62 WLB_0 WLB_3 WLB_4
+  WLB_7 WLB_8 WLB_11 WLB_12 WLB_15 WLB_16 WLB_19 WLB_20 WLB_23 WLB_24 WLB_27
+  WLB_28 WLB_31 WLB_32 WLB_35 WLB_36 WLB_39 WLB_40 WLB_43 WLB_44 WLB_47
+  WLB_48 WLB_51 WLB_52 WLB_55 WLB_56 WLB_59 WLB_60 WLB_63 WLB_1 WLB_2 WLB_5
+  WLB_6 WLB_9 WLB_10 WLB_13 WLB_14 WLB_17 WLB_18 WLB_21 WLB_22 WLB_25 WLB_26
+  WLB_29 WLB_30 WLB_33 WLB_34 WLB_37 WLB_38 WLB_41 WLB_42 WLB_45 WLB_46
+  WLB_49 WLB_50 WLB_53 WLB_54 WLB_57 WLB_58 WLB_61 WLB_62 XP0_0 XP0_1 XP0_2
+  XP0_3 XP1_0 XP1_1 XP1_2 XP1_3 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS Mem_cnnin2WORD_ROWSB
XI4_1 AB[1] AB[0] AGTP A0A A0A_ A0B A0B_ VSS VSS CLKB GSRCN_1710 GTPN_1708 VSS
+  VSS RST STUBWEA STUBWEB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS
+  Mem_cnnin2Y_DECODEB
XI5_1 AB[5] AB[2] AB[6] AB[3] AB[7] AB[4] AGTP AGTP A0A A0A_ A0B A0B_ VSS VSS
+  VSS VSS STUBWEA STUBWEB XP0_3 XP2_0 XP1_3 XP2_1 XP0_2 XP2_2 XP1_2 XP2_3
+  XP0_1 XP2_4 XP1_1 XP2_5 XP0_0 XP2_6 XP1_0 XP2_7 YPA0_0 YPA0_1 VSS VSS VSS
+  VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VDD VSS
+  Mem_cnnin2X_PRE_DECODEB
XI7_1 AA[5] AA[2] AA[6] AA[3] AA[7] AA[4] AGTPAT AGTPAT A0A A0A_ A0B A0B_ VSS
+  VSS VSS VSS STUBWEA STUBWEB XP_0_0 XP_0_1 XP_1_0 XP_1_1 XP_2_0 XP_2_1
+  XP_3_0 XP_3_1 XP_4_0 XP_4_1 XP_5_0 XP_5_1 XP_6_0 XP_6_1 XP_7_0 XP_7_1
+  YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS
+  VDD VSS Mem_cnnin2X_PRE_DECODEA
XI7_3 VDD GTPA_2 GTPB_2 MBL MBLA_ MWLD MWLBD MWLD WLA_0 WLA_3 WLA_4 WLA_7
+  WLA_8 WLA_11 WLA_12 WLA_15 WLA_16 WLA_19 WLA_20 WLA_23 WLA_24 WLA_27 WLA_28
+  WLA_31 WLA_32 WLA_35 WLA_36 WLA_39 WLA_40 WLA_43 WLA_44 WLA_47 WLA_48
+  WLA_51 WLA_52 WLA_55 WLA_56 WLA_59 WLA_60 WLA_63 WLA_1 WLA_2 WLA_5 WLA_6
+  WLA_9 WLA_10 WLA_13 WLA_14 WLA_17 WLA_18 WLA_21 WLA_22 WLA_25 WLA_26 WLA_29
+  WLA_30 WLA_33 WLA_34 WLA_37 WLA_38 WLA_41 WLA_42 WLA_45 WLA_46 WLA_49
+  WLA_50 WLA_53 WLA_54 WLA_57 WLA_58 WLA_61 WLA_62 WLB_0 WLB_3 WLB_4 WLB_7
+  WLB_8 WLB_11 WLB_12 WLB_15 WLB_16 WLB_19 WLB_20 WLB_23 WLB_24 WLB_27 WLB_28
+  WLB_31 WLB_32 WLB_35 WLB_36 WLB_39 WLB_40 WLB_43 WLB_44 WLB_47 WLB_48
+  WLB_51 WLB_52 WLB_55 WLB_56 WLB_59 WLB_60 WLB_63 WLB_1 WLB_2 WLB_5 WLB_6
+  WLB_9 WLB_10 WLB_13 WLB_14 WLB_17 WLB_18 WLB_21 WLB_22 WLB_25 WLB_26 WLB_29
+  WLB_30 WLB_33 WLB_34 WLB_37 WLB_38 WLB_41 WLB_42 WLB_45 WLB_46 WLB_49
+  WLB_50 WLB_53 WLB_54 WLB_57 WLB_58 WLB_61 WLB_62 XP_6_0 XP_4_0 XP_2_0
+  XP_0_0 XP_7_0 XP_5_0 XP_3_0 XP_1_0 XP_0_1 XP_1_1 XP_2_1 XP_3_1 XP_4_1
+  XP_5_1 XP_6_1 XP_7_1 VDD VSS Mem_cnnin2WORD_ROWSA
XI8_1 AA[1] AA[0] AGTPAT A0A A0A_ A0B A0B_ VSS VSS CLKA GSRCN GTPN VSS VSS
+  RST_1748 STUBWEA STUBWEB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VDD VSS
+  Mem_cnnin2Y_DECODEA
XI9_0 CENA CLKA GSRCN GTPA_2 GTPB_2 GTPN MBL RST_1748 VSS VSS STUBWEA STUBWEB
+  WENA VDD VSS Mem_cnnin2HBFX_A
XI9_2 A0A A0A_ A0B A0B_ AGTPAT CLKA GSRCN GTPN GTPA_2 GTPA_2 GTPA_2 GTPA_2
+  RST_1748 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VDD VSS Mem_cnnin2CLK_DRVS
.ENDS Mem_cnnin2
